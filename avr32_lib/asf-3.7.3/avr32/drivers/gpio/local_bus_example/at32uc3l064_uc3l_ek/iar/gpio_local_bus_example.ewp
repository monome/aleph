# IAR project gpio_local_bus_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3L_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../utils/preprocessor; ../../../../scif; ../../../../../boards/uc3l_ek; ../../../../../../common/boards; ../../../../../boards; ../../../../../utils; ../../..; ../../../../../../common/utils; ../../../../pm; ../../../../flashcdw; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 2
  AAVR32.ADefines: BOARD=UC3L_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/flashcdw
    ../../../../flashcdw/: flashcdw.c
  group avr32/drivers/gpio
    ../../../: gpio.c
  group avr32/drivers/gpio/local_bus_example
    ../../: gpio_local_bus_example.c
  group avr32/drivers/pm
    ../../../../pm/: power_clocks_lib.c pm_uc3l.c
  group avr32/drivers/scif
    ../../../../scif/: scif_uc3l.c
  group avr32/boards/uc3l_ek
    ../../../../../boards/uc3l_ek/: led.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
