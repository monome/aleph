# IAR project mt48lc16m16a2tg7e_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../common/services/serial; ../../../../../../../utils/preprocessor; ../../../../../../../boards/uc3c_ek; ../../../../../../../../common/services/clock; ../../../../../../../../common/services/serial/uc3_usart; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../common/boards; ../../../../../../../drivers/ebi/sdramc; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../../../../../../drivers/scif; ../../../../../../../boards; ../../../../../../../utils; ../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../drivers/gpio; ../../../../../../../utils/debug; ../../../../../../../drivers/pm; ../../../../../../../../common/utils; ../../../..; ../..; ..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/services/clock/uc3c
    ../../../../../../../../common/services/clock/uc3c/: pll.c sysclk.c osc.c
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: pm_uc3c.c power_clocks_lib.c
  group avr32/drivers/scif
    ../../../../../../../drivers/scif/: scif_uc3c.c
  group avr32/drivers/ebi/sdramc
    ../../../../../../../drivers/ebi/sdramc/: sdramc.c
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c
  group avr32/components/memory/sdram/mt48lc16m16a2tg7e/unit_tests
    ../../: unit_tests.c main.c
  group avr32/boards/uc3c_ek
    ../../../../../../../boards/uc3c_ek/: led.c init.c
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82
