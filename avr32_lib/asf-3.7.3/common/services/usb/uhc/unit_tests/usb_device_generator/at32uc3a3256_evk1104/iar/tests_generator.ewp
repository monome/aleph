# IAR project tests_generator.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../../delay; ../../../../../../../../avr32/utils/preprocessor; ../../../../../../clock; ..; ../../../../../class/hid; ../../../../../../../boards; ../../../../..; ../../../../../../../../avr32/drivers/flashc; ../../../../../../../../avr32/boards/evk1104; ../../../../../../../../avr32/boards; ../../../../../../../../avr32/utils; ../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../../../avr32/drivers/gpio; ../../../../../../../../avr32/drivers/usbb; ../../../../../../../utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/gpio
    ../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/flashc
    ../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/boards/evk1104
    ../../../../../../../../avr32/boards/evk1104/: led.c init.c
  group avr32/utils/startup
    ../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/usb/uhc/unit_tests/usb_device_generator
    ../../: unit_tests.c
  group common/services/clock/uc3a3_a4
    ../../../../../../clock/uc3a3_a4/: sysclk.c
