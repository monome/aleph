# IAR project stdio_serial_stdio_serial_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils/header_files; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ..; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../../sam/drivers/usart; ../../..; ../../../../../../boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/utils/fpu; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../sam/utils/cmsis/sam4e/include; ../../../../..; ../../../../../../../sam/boards/sam4e_ek; ../../../../../../services/serial; ../../../../../../services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: stdio_serial_stdio_serial_example_flash.bin
  ILINK.IlinkOutputFile: stdio_serial_stdio_serial_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_serial/stdio_serial_example
    ../../: stdio_serial_example.c
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c
  group common/services/clock/sam4e
    ../../../../../../services/clock/sam4e/: sysclk.c
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c
  group sam/boards/sam4e_ek
    ../../../../../../../sam/boards/sam4e_ek/: init.c
