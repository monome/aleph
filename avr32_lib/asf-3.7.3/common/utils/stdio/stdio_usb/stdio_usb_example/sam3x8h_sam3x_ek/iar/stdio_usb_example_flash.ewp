# IAR project stdio_usb_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3X8H__; BOARD=SAM3X_EK; UDD_ENABLE
  ICCARM.CCIncludePath2: ../../../../../../services/usb/class/cdc/device; ../../../../../../../sam/drivers/uotghs; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/boards/sam3x_ek; ../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../../sam/utils/cmsis/sam3x/include; ../../..; ../../../../../../services/sleepmgr; ../../../../..; ../../../../../../services/usb/class/cdc; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../services/gpio; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../../sam/drivers/pio; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3X8H__; BOARD=SAM3X_EK; UDD_ENABLE
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: stdio_usb_example_flash.bin
  ILINK.IlinkOutputFile: stdio_usb_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../: stdio_usb.c
  group common/utils/stdio/stdio_usb/stdio_usb_example
    ../../: stdio_usb_example.c
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3x
    ../../../../../../services/clock/sam3x/: sysclk.c
  group common/services/usb/class/cdc/device
    ../../../../../../services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c
  group common/services/sleepmgr/sam
    ../../../../../../services/sleepmgr/sam/: sleepmgr.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/drivers/uotghs
    ../../../../../../../sam/drivers/uotghs/: uotghs_device.c
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/boards/sam3x_ek
    ../../../../../../../sam/boards/sam3x_ek/: init.c led.c
