# IAR project nvm_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3u ATxmega256A3U
  ICCAVR.CCDefines: BOARD=STK600_RC064X; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; USE_EXTMEM; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../xmega/boards/stk600/rc064x; ../../../../../services/spi/xmega_spi; ../../../../../services/clock; ../../../../../services/gpio; ../../../../../services/spi; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../components/memory/data_flash/at45dbx; ../../../../../../xmega/utils; ../../../../../../xmega/drivers/spi; ..; ../../../../../services/ioport; ../../..; ../../../../../../xmega/boards; ../../../../../../xmega/drivers/nvm; ../../../../../utils; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC064X; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; USE_EXTMEM; IOPORT_XMEGA_COMPAT
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/spi
    ../../../../../../xmega/drivers/spi/: spi.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/stk600/rc064x
    ../../../../../../xmega/boards/stk600/rc064x/: init.c
  group common/services/spi/xmega_spi
    ../../../../../services/spi/xmega_spi/: spi_master.c
  group common/services/clock/xmega
    ../../../../../services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../../services/ioport/xmega/: ioport_compat.c
  group common/drivers/nvm/xmega
    ../../../xmega/: xmega_nvm.c
  group common/drivers/nvm/example
    ../../: nvm_example.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../components/memory/data_flash/at45dbx/: at45dbx.c
