# IAR project tests_generator_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../..; ../../../../../../delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../clock; ../../../../../../../../sam/boards; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../..; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../../../sam/boards/sam3x_ek; ../../../../../class/hid; ..; ../../../../../../../utils; ../../../../../../gpio; ../../../../../../../../sam/drivers/uotghs; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tests_generator_flash.bin
  ILINK.IlinkOutputFile: tests_generator_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam/boards/sam3x_ek
    ../../../../../../../../sam/boards/sam3x_ek/: init.c led.c
  group common/services/delay/sam
    ../../../../../../delay/sam/: cycle_counter.c
  group common/services/usb/uhc/unit_tests/usb_device_generator
    ../../: unit_tests.c
  group common/services/clock/sam3x
    ../../../../../../clock/sam3x/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
