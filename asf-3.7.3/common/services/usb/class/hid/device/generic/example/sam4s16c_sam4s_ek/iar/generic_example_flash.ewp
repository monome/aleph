# IAR project generic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; UDD_ENABLE; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pio; ../../..; ../../../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam/boards/sam4s_ek; ..; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam/drivers/udp; ../../../../../../../../gpio; ../../../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../boards; ../..; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pmc; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; UDD_ENABLE; ARM_MATH_CM4=true; __SAM4S16C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generic_example_flash.bin
  ILINK.IlinkOutputFile: generic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/generic
    ../../../: udi_hid_generic.c udi_hid_generic_desc.c
  group common/services/usb/class/hid/device/generic/example
    ../../: main.c
  group common/services/usb/class/hid/device/generic/example/sam4s16c_sam4s_ek
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/clock/sam4s
    ../../../../../../../../clock/sam4s/: sysclk.c
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c
  group sam/boards/sam4s_ek
    ../../../../../../../../../../sam/boards/sam4s_ek/: led.c init.c
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/udp
    ../../../../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
