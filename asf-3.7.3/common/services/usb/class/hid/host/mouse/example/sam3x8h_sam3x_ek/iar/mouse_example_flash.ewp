# IAR project mouse_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: UHD_ENABLE; BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/drivers/uotghs; ../../..; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../../sam/boards/sam3x_ek; ../..; ../../../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../uhc; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ..; ../../../../../../..; ../../../../../../../../gpio; ../../../../../../../../../../sam/drivers/uart; ../../../../../../../../../../sam/utils; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../boards; ../../../../../../../../../../sam/drivers/pio; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: UHD_ENABLE; BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_example_flash.bin
  ILINK.IlinkOutputFile: mouse_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb/uhc
    ../../../../../../../uhc/: uhc.c
  group common/services/usb/class/hid/host/mouse
    ../../../: uhi_hid_mouse.c
  group common/services/usb/class/hid/host/mouse/example
    ../../: main.c
  group common/services/usb/class/hid/host/mouse/example/sam3x8h_sam3x_ek
    ../: ui.c
  group common/services/clock/sam3x
    ../../../../../../../../clock/sam3x/: sysclk.c
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group sam/drivers/uart
    ../../../../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/uotghs
    ../../../../../../../../../../sam/drivers/uotghs/: uotghs_host.c
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/boards/sam3x_ek
    ../../../../../../../../../../sam/boards/sam3x_ek/: led.c init.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
