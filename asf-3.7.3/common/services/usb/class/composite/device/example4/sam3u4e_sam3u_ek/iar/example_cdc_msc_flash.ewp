# IAR project example_cdc_msc_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ACCESS_USB_ENABLED; VIRTUAL_MEMORY_ENABLE; UDD_ENABLE; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../cdc/device; ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pmc; ../../../../../msc; ../..; ../../../../../../../../../sam/drivers/ebi/smc; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../cdc; ..; ../../../../../msc/device; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../../../../sam/drivers/udphs; ../../../../../../../../../sam/boards/sam3u_ek; ../../../../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../..; ../../../../../../../gpio; ../../../../../../../../../sam/utils; ../../../../../../udc; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pio; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_cdc_msc_flash.bin
  ILINK.IlinkOutputFile: example_cdc_msc_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/ebi/smc
    ../../../../../../../../../sam/drivers/ebi/smc/: smc.c
  group sam/drivers/udphs
    ../../../../../../../../../sam/drivers/udphs/: udphs_device.c
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/: exceptions.c system_sam3u.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/boards/sam3u_ek
    ../../../../../../../../../sam/boards/sam3u_ek/: init.c led.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/usb/class/composite/device
    ../../../: udi_composite_desc.c
  group common/services/usb/class/composite/device/example4
    ../../: uart_sam.c memories_initialization_sam.c main.c
  group common/services/usb/class/composite/device/example4/sam3u4e_sam3u_ek
    ../: ui.c
  group common/services/usb/class/cdc/device
    ../../../../../cdc/device/: udi_cdc.c
  group common/services/usb/class/msc/device
    ../../../../../msc/device/: udi_msc.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/clock/sam3u
    ../../../../../../../clock/sam3u/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c
