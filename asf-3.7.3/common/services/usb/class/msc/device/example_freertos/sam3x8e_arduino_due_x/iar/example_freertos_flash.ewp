# IAR project example_freertos_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FREERTOS_USED; ACCESS_USB_ENABLED; UDD_ENABLE; VIRTUAL_MEMORY_ENABLE; __SAM3X8E__; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ../../../../../../../../../sam/drivers/uotghs; ../..; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam; ../../..; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/pio; ..; ../../../../../../../gpio; ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/include; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../..; ../../../../../../../../../sam/boards/arduino_due_x; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_freertos_flash.bin
  ILINK.IlinkOutputFile: example_freertos_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x4000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/example_freertos
    ../../: memories_initialization_sam.c exceptions_sam.c main.c
  group common/services/usb/class/msc/device/example_freertos/sam3x8e_arduino_due_x
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/clock/sam3x
    ../../../../../../../clock/sam3x/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/uotghs
    ../../../../../../../../../sam/drivers/uotghs/: uotghs_device.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/boards/arduino_due_x
    ../../../../../../../../../sam/boards/arduino_due_x/: led.c init.c
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/: croutine.c queue.c list.c tasks.c timers.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s
