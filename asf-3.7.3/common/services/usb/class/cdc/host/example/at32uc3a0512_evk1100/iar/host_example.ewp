# IAR project host_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: UHD_ENABLE; BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../..; ../../../../../../uhc; ../../../../../../../clock; ../../../../../../../../boards; ../..; ../../..; ../../../../../../../../../avr32/boards; ../../../../../../../../../avr32/drivers/usart; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../avr32/drivers/pm; ../../../../../..; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/boards/evk1100; ../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../../../avr32/drivers/usbb; ../../../../../../../sleepmgr; ../../../../../../../../utils; ..; ../../../../../../../../../avr32/drivers/gpio; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: UHD_ENABLE; BOARD=EVK1100
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/boards/evk1100
    ../../../../../../../../../avr32/boards/evk1100/: init.c led.c
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_conf_clocks.c pm.c
  group avr32/drivers/usart
    ../../../../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usbb
    ../../../../../../../../../avr32/drivers/usbb/: usbb_host.c
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/usb/class/cdc/host
    ../../../: uhi_cdc.c
  group common/services/usb/class/cdc/host/example
    ../../: main.c uart_uc3.c
  group common/services/usb/class/cdc/host/example/at32uc3a0512_evk1100
    ../: ui.c
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3a0_a1
    ../../../../../../../clock/uc3a0_a1/: sysclk.c
