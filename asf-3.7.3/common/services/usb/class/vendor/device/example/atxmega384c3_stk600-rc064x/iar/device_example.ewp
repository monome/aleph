# IAR project device_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm384c3 ATxmega384C3
  ICCAVR.CCDefines: BOARD=STK600_RC064X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../../xmega/drivers/usb; ../..; ../../../../../../../../../xmega/boards/stk600/rc064x; ../../../..; ../../../../../../../clock; ../../../../../../../gpio; ../../../../../../../../../xmega/drivers/nvm; ../../../../../../../../boards; ../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../xmega/utils; ../../../../../../udc; ../../../../../..; ../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../utils; ../../../../../../../../../xmega/boards; ..; ../../../../../../../sleepmgr; ../../..; ../../../../../../../../../xmega/drivers/cpu; ../../../../../../../ioport; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC064X; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC064X; IOPORT_XMEGA_COMPAT
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/usb/class/vendor/device
    ../../../: udi_vendor_desc.c udi_vendor.c
  group common/services/usb/class/vendor/device/example
    ../../: main.c
  group common/services/usb/class/vendor/device/example/atxmega384c3_stk600-rc064x
    ../: ui.c
  group common/services/ioport/xmega
    ../../../../../../../ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../../clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../../sleepmgr/xmega/: sleepmgr.c
  group xmega/drivers/usb
    ../../../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/nvm
    ../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/stk600/rc064x
    ../../../../../../../../../xmega/boards/stk600/rc064x/: init.c
