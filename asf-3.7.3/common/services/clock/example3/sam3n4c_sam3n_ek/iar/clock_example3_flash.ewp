# IAR project clock_example3_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ..; ../../..; ../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ../../../../../../sam/boards/sam3n_ek; ../../../../../utils; ../../../../gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; __SAM3N4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: clock_example3_flash.bin
  ILINK.IlinkOutputFile: clock_example3_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../sam/utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/boards/sam3n_ek
    ../../../../../../sam/boards/sam3n_ek/: init.c led.c
  group common/services/clock/example3
    ../../: clock_example3_sam.c
  group common/services/clock/sam3n
    ../../../sam3n/: sysclk.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
