# IAR project master_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1105; CONFIG_INTERRUPT_FORCE_INTC
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../avr32/boards/evk1105; ../../../../../../avr32/drivers/gpio; ../../../../clock; ../../../../../boards; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/drivers/twi; ../../../../../../avr32/utils; ../../../../../../avr32/utils/preprocessor; ..; ../../../../../utils; ../../../../../../avr32/drivers/intc; ../../..; ../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105; CONFIG_INTERRUPT_FORCE_INTC
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c exception.s82
  group avr32/drivers/twi
    ../../../../../../avr32/drivers/twi/: twi.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/boards/evk1105
    ../../../../../../avr32/boards/evk1105/: init.c led.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/twi/master_example
    ../../: twi_master_example.c
  group common/services/clock/uc3a0_a1
    ../../../../clock/uc3a0_a1/: sysclk.c
