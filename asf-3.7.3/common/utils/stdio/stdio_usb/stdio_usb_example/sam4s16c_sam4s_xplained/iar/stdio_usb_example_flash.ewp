# IAR project stdio_usb_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; UDD_ENABLE; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../services/usb/class/cdc; ../../../../../../services/usb/class/cdc/device; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/utils/cmsis/sam4s/include; ../../..; ../../../../../../services/sleepmgr; ../../../../..; ..; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../../sam/drivers/udp; ../../../../../../services/gpio; ../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/boards/sam4s_xplained; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: stdio_usb_example_flash.bin
  ILINK.IlinkOutputFile: stdio_usb_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_xplained
    ../../../../../../../sam/boards/sam4s_xplained/: led.c init.c
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/udp
    ../../../../../../../sam/drivers/udp/: udp_device.c
  group common/utils/stdio
    ../../../../: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../: stdio_usb.c
  group common/utils/stdio/stdio_usb/stdio_usb_example
    ../../: stdio_usb_example.c
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_sam_nvic.c
  group common/services/usb/class/cdc/device
    ../../../../../../services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c
  group common/services/sleepmgr/sam
    ../../../../../../services/sleepmgr/sam/: sleepmgr.c
  group common/services/clock/sam4s
    ../../../../../../services/clock/sam4s/: sysclk.c
