# IAR project stdio_usb_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: UDD_ENABLE; BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../services/usb/class/cdc; ../../../../../../../avr32/utils; ../../../../../../services/usb/class/cdc/device; ../../../../../../../avr32/drivers/gpio; ../../../../../../services/clock; ../../../../../../../avr32/drivers/pm; ../..; ../../../../../../boards; ../../../../../../services/usb; ../../../../../../../avr32/boards; ../../../../../../../avr32/drivers/flashc; ../../../../../../services/usb/udc; ../../..; ..; ../../../../../../../avr32/boards/evk1100; ../../../../../../../avr32/utils/preprocessor; ../../../../../../../avr32/drivers/usbb; ../../../../../../services/sleepmgr; ../../../../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: UDD_ENABLE; BOARD=EVK1100
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/pm
    ../../../../../../../avr32/drivers/pm/: pm_conf_clocks.c pm.c power_clocks_lib.c
  group avr32/drivers/usbb
    ../../../../../../../avr32/drivers/usbb/: usbb_device.c
  group avr32/drivers/flashc
    ../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/gpio
    ../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/boards/evk1100
    ../../../../../../../avr32/boards/evk1100/: led.c init.c
  group avr32/utils/startup
    ../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/sleepmgr/uc3
    ../../../../../../services/sleepmgr/uc3/: sleepmgr.c
  group common/services/usb/class/cdc/device
    ../../../../../../services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c
  group common/services/clock/uc3a0_a1
    ../../../../../../services/clock/uc3a0_a1/: sysclk.c
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../: stdio_usb.c
  group common/utils/stdio/stdio_usb/stdio_usb_example
    ../../: stdio_usb_example.c
