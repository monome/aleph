# IAR project stdio_serial_stdio_serial_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../../../../../../avr32/drivers/gpio; ../../../../../../services/clock; ../../../../../../services/serial/uc3_usart; ../../../../../../services/serial; ../../../../../../boards; ../../../../../../../avr32/drivers/usart; ../../../../../../../avr32/boards; ../../../../../../../avr32/utils; ../../../../../../../avr32/drivers/flashcdw; ../../../../../../../avr32/utils/preprocessor; ../../../../../../../avr32/boards/uc3_l0_xplained; ../../../../..; ..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock/uc3l
    ../../../../../../services/clock/uc3l/: dfll.c osc.c sysclk.c
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_serial/stdio_serial_example
    ../../: stdio_serial_example.c
  group avr32/boards/uc3_l0_xplained
    ../../../../../../../avr32/boards/uc3_l0_xplained/: init.c led.c
  group avr32/drivers/flashcdw
    ../../../../../../../avr32/drivers/flashcdw/: flashcdw.c
  group avr32/drivers/usart
    ../../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/gpio
    ../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/utils/startup
    ../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
