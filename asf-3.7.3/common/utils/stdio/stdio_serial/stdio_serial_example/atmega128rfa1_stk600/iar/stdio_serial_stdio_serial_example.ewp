# IAR project stdio_serial_stdio_serial_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_MEGA_RF
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: ../../../../../../../mega/boards/stk600; ../../../../../../services/serial/megarf_usart; ../../../../../../../mega/drivers/cpu; ../../../../../../../mega/utils; ../../../../../../services/clock; ../../..; ../../../../../../boards; ../../../../../../services/ioport; ..; ../../../../..; ../../../../../../../mega/boards/stk600/rc128x_rfx; ../../../../../../services/gpio; ../../../../../../../mega/drivers/usart; ../../../../../../services/serial; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_MEGA_RF
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_MEGA_RF
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_serial/stdio_serial_example
    ../../: stdio_serial_example.c
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c
  group common/services/clock/mega
    ../../../../../../services/clock/mega/: sysclk.c
  group mega/drivers/usart
    ../../../../../../../mega/drivers/usart/: usart_megarf.c
  group mega/boards/stk600/rc128x_rfx
    ../../../../../../../mega/boards/stk600/rc128x_rfx/: init.c
