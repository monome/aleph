# IAR project sd_mmc_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=EVK1101
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../../../../../../avr32/boards; ../../../../../../services/spi/uc3_spi; ../../../../../../services/serial; ../../../../../../../avr32/utils; ../../../../../../../avr32/boards/evk1101; ../../../../../../../avr32/drivers/gpio; ../../../../../../utils; ../../../../../../../avr32/drivers/spi; ../../../../../../services/clock; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../services/delay; ../..; ../../../../../../services/serial/uc3_usart; ../../../../../../services/spi; ../../../../../../boards; ../../../../../../../avr32/drivers/usart; ../../../../../../../avr32/drivers/flashc; ../../../../../../services/ioport; ../../../../../../../avr32/utils/preprocessor; ..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../avr32/utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../utils/unit_test/: suite.c
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_spi.c sd_mmc.c
  group common/components/memory/sd_mmc/unit_tests
    ../../: unit_tests.c
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c
  group common/services/clock/uc3b0_b1
    ../../../../../../services/clock/uc3b0_b1/: sysclk.c
  group common/services/spi/uc3_spi
    ../../../../../../services/spi/uc3_spi/: spi_master.c
  group avr32/drivers/spi
    ../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/drivers/flashc
    ../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usart
    ../../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/gpio
    ../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/boards/evk1101
    ../../../../../../../avr32/boards/evk1101/: led.c init.c
  group avr32/utils/startup
    ../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
