# IAR project sd_mmc_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; SD_MMC_ENABLE; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../..; ../../../../../../services/serial/sam_uart; ../../../../../../services/spi/sam_spi; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../..; ../../../../../../services/serial; ../../../../../../../sam/drivers/rtc; ../../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../../sam/drivers/spi; ../../../../../../utils; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../sam/boards/sam3n_ek; ../../../../../../services/gpio; ../../../../../../services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ..; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; ../../../../../../services/spi; ../../../../../../services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; SD_MMC_ENABLE; __SAM3N4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_example2_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../../services/storage/ctrl_access/: ctrl_access.c
  group common/services/clock/sam3n
    ../../../../../../services/clock/sam3n/: sysclk.c
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_spi.c sd_mmc_mem.c sd_mmc.c
  group common/components/memory/sd_mmc/example2
    ../../: example.c
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group sam/boards/sam3n_ek
    ../../../../../../../sam/boards/sam3n_ek/: led.c init.c
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../../sam/utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c
  group sam/drivers/rtc
    ../../../../../../../sam/drivers/rtc/: rtc.c
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
