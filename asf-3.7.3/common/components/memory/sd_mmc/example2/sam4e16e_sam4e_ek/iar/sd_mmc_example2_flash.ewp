# IAR project sd_mmc_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __SAM4E16E__; SD_MMC_ENABLE; ARM_MATH_CM4=true; BOARD=SAM4E_EK
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../sam/utils/header_files; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../..; ../../../../../../../sam/utils/fpu; ../../../../../../services/serial; ..; ../../../../../../services/ioport; ../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../sam/drivers/pdc; ../../../../../../utils; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../sam/utils/cmsis/sam4e/include; ../../../../../../services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ../../../../../../../sam/drivers/usart; ../../../../../../services/serial/sam_uart; ../../../../../../boards; ../../../../../../../sam/drivers/rtc; ../../../../../../../sam/drivers/hsmci; ../../../../../../../sam/boards/sam4e_ek; ../../../../../../services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_example2_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../../services/storage/ctrl_access/: ctrl_access.c
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c
  group common/services/clock/sam4e
    ../../../../../../services/clock/sam4e/: sysclk.c
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_mem.c sd_mmc.c
  group common/components/memory/sd_mmc/example2
    ../../: example.c
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/rtc
    ../../../../../../../sam/drivers/rtc/: rtc.c
  group sam/drivers/hsmci
    ../../../../../../../sam/drivers/hsmci/: hsmci.c
  group sam/drivers/pdc
    ../../../../../../../sam/drivers/pdc/: pdc.c
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c
  group sam/boards/sam4e_ek
    ../../../../../../../sam/boards/sam4e_ek/: init.c
