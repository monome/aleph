# IAR project nvm_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM4S_EK; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../services/serial/sam_uart; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../..; ../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../sam/drivers/efc; ../../../../../services/serial; ../../../../../../sam/services/flash_efc; ../../../../../utils; ..; ../../../../../../sam/boards/sam4s_ek; ../../../../../services/clock; ../../../../../../sam/boards; ../../../../../utils/stdio/stdio_serial; ../../../../../services/gpio; ../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../services/ioport; ../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nvm_unit_tests_flash.bin
  ILINK.IlinkOutputFile: nvm_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/drivers/nvm/sam
    ../../../sam/: sam_nvm.c
  group common/drivers/nvm/unit_tests
    ../../: unit_tests.c
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c
  group common/services/serial
    ../../../../../services/serial/: usart_serial.c
  group common/services/clock/sam4s
    ../../../../../services/clock/sam4s/: sysclk.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/boards/sam4s_ek
    ../../../../../../sam/boards/sam4s_ek/: led.c init.c
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
