# IAR project nvm_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; BOARD=EVK1104; TEST_SUITE_DEFINE_ASSERT_MACRO
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../services/serial; ../../../../../../avr32/drivers/gpio; ../../../../../services/clock; ../../../../../services/serial/uc3_usart; ../../../../../utils/stdio/stdio_serial; ../../../../../boards; ../../../../../../avr32/boards; ..; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/boards/evk1104; ../../../../../services/ioport; ../../../../../../avr32/utils; ../../..; ../../../../../../avr32/utils/preprocessor; ../../../../../utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/drivers/nvm/uc3
    ../../../uc3/: uc3_nvm.c
  group common/drivers/nvm/unit_tests
    ../../: unit_tests.c
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/services/clock/uc3a3_a4
    ../../../../../services/clock/uc3a3_a4/: sysclk.c
  group common/services/serial
    ../../../../../services/serial/: usart_serial.c
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/boards/evk1104
    ../../../../../../avr32/boards/evk1104/: init.c led.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
