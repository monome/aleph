# IAR project nvm_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../../../xmega/drivers/pmic; ../../../../../services/clock; ../../../../../services/gpio; ../../../../../utils/stdio/stdio_serial; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/utils; ../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../services/ioport; ../../../../../../xmega/drivers/usart; ../../..; ../../../../../../xmega/boards; ../../../../../../xmega/drivers/nvm; ../../../../../utils; ../../../../../services/serial/xmega_usart; ../../../../../../xmega/drivers/cpu; ../../../../../services/serial; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/drivers/nvm/unit_tests
    ../../: unit_tests.c
  group common/drivers/nvm/xmega
    ../../../xmega/: xmega_nvm.c
  group common/services/clock/xmega
    ../../../../../services/clock/xmega/: sysclk.c
  group common/services/serial
    ../../../../../services/serial/: usart_serial.c
  group common/services/ioport/xmega
    ../../../../../services/ioport/xmega/: ioport_compat.c
