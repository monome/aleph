# IAR project nvm_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XPLAIN; USE_EXTMEM; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../services/clock; ../../../../../services/gpio; ../../../../../services/spi; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../components/memory/data_flash/at45dbx; ../../../../../../xmega/utils; ../../../../../../xmega/drivers/spi; ../../../../../services/spi/xmega_spi; ../../../../../services/ioport; ../../..; ../../../../../../xmega/boards; ../../../../../../xmega/drivers/nvm; ..; ../../../../../utils; ../../../../../../xmega/boards/xplain; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=XPLAIN; USE_EXTMEM; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XPLAIN; USE_EXTMEM; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/spi/xmega_spi
    ../../../../../services/spi/xmega_spi/: spi_master.c
  group common/services/clock/xmega
    ../../../../../services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../../services/ioport/xmega/: ioport_compat.c
  group common/drivers/nvm/xmega
    ../../../xmega/: xmega_nvm.c
  group common/drivers/nvm/example
    ../../: nvm_example.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../components/memory/data_flash/at45dbx/: at45dbx.c
  group xmega/drivers/spi
    ../../../../../../xmega/drivers/spi/: spi.c
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xplain
    ../../../../../../xmega/boards/xplain/: init.c
