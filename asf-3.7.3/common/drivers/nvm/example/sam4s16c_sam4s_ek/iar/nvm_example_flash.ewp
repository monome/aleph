# IAR project nvm_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../sam/boards/sam4s_ek; ../../../../../../sam/utils; ../../../../../services/clock; ..; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pio; ../../../../../services/ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/services/flash_efc; ../../..; ../../../../../../sam/boards; ../../../../../utils; ../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../services/gpio; ../../../../../../sam/drivers/efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nvm_example_flash.bin
  ILINK.IlinkOutputFile: nvm_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/drivers/nvm/sam
    ../../../sam/: sam_nvm.c
  group common/drivers/nvm/example
    ../../: nvm_example.c
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam4s
    ../../../../../services/clock/sam4s/: sysclk.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_ek
    ../../../../../../sam/boards/sam4s_ek/: init.c led.c
