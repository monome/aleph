# IAR project nvm_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104; USE_EXTMEM
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../../avr32/drivers/gpio; ../../../../../../avr32/utils; ../../../../../services/clock; ../../../../../services/spi; ../../../../../boards; ../../../../../../avr32/boards; ../../../../../components/memory/data_flash/at45dbx; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/boards/evk1104; ../../../../../services/ioport; ../../../../../services/spi/uc3_spi; ../../..; ../../../../../../avr32/utils/preprocessor; ../../../../../utils; ../../../../../../avr32/drivers/spi; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104; USE_EXTMEM
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/drivers/nvm/uc3
    ../../../uc3/: uc3_nvm.c
  group common/drivers/nvm/example
    ../../: nvm_example.c
  group common/services/clock/uc3a3_a4
    ../../../../../services/clock/uc3a3_a4/: sysclk.c
  group common/services/spi/uc3_spi
    ../../../../../services/spi/uc3_spi/: spi_master.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../components/memory/data_flash/at45dbx/: at45dbx.c
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/spi
    ../../../../../../avr32/drivers/spi/: spi.c
  group avr32/boards/evk1104
    ../../../../../../avr32/boards/evk1104/: led.c init.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
