# IAR project spi_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=UC3C_EK; SD_MMC_SPI_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../conf; ../../../../../../../utils/preprocessor; ../../../../../../../boards/uc3c_ek; ../../../../../../../../common/services/clock; ..; ../../../../../../../../common/services/serial; ../../../../../../../../common/boards; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../../../../../../boards; ../../../../../../../utils; ../../../../../../../drivers/gpio; ../../../../../../../../common/services/serial/uc3_usart; ../../../../../../../../common/utils; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../drivers/spi; ../../../../../../../../common/services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c
  group common/services/clock/uc3c
    ../../../../../../../../common/services/clock/uc3c/: pll.c sysclk.c osc.c
  group common/services/storage/ctrl_access
    ../../../../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c
  group avr32/components/memory/sd_mmc/sd_mmc_spi
    ../../../: sd_mmc_spi.c sd_mmc_spi_mem.c
  group avr32/components/memory/sd_mmc/sd_mmc_spi/unit_tests
    ../../: unit_tests.c
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/spi
    ../../../../../../../drivers/spi/: spi.c
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c
  group avr32/boards/uc3c_ek
    ../../../../../../../boards/uc3c_ek/: led.c init.c
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82
