# IAR project flashc_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1101
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../utils/preprocessor; ../../../../../utils/debug; ../../../../../../common/boards; ../../../../usart; ../../..; ../../../../../boards; ../../../../../utils; ../../../../../boards/evk1101; ../../../../gpio; ../../../../pm; ../../../../../../common/utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/utils/debug
    ../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/drivers/pm
    ../../../../pm/: pm.c power_clocks_lib.c pm_conf_clocks.c
  group avr32/drivers/flashc
    ../../../: flashc.c
  group avr32/drivers/flashc/flash_example
    ../../: flash_example.c
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../usart/: usart.c
  group avr32/boards/evk1101
    ../../../../../boards/evk1101/: led.c
