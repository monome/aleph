# IAR project ssc_i2s_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1101
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../gpio; ../../..; ../../../../../../../common/boards; ../../../../../flashc; ../../../../../../boards; ../../../../../../utils; ../../../../../../boards/evk1101; ../../../../../../utils/preprocessor; ../../../../../../../common/utils; ../../../../../pm; ../../../../../intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/ssc/i2s
    ../../../: ssc_i2s.c
  group avr32/drivers/ssc/i2s/example
    ../../: ssc_i2s_example.c
  group avr32/drivers/pm
    ../../../../../pm/: pm_conf_clocks.c power_clocks_lib.c pm.c
  group avr32/drivers/gpio
    ../../../../../gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../intc/: intc.c exception.s82
  group avr32/drivers/flashc
    ../../../../../flashc/: flashc.c
  group avr32/boards/evk1101
    ../../../../../../boards/evk1101/: led.c
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82
