# IAR project pdca_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../utils; ../../../../../boards/uc3c_ek; ../../../../gpio; ..; ../../../../../../common/services/clock; ../../../../../../common/boards; ../../../../../boards; ../../../../usart; ../../../../flashc; ../../../../scif; ../../../../pm; ../../..; ../..; ../../../../../utils/preprocessor; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c
  group avr32/drivers/flashc
    ../../../../flashc/: flashc.c
  group avr32/drivers/pdca
    ../../../: pdca.c
  group avr32/drivers/pdca/example
    ../../: pdca_example.c
  group avr32/drivers/pm
    ../../../../pm/: power_clocks_lib.c pm_uc3c.c
  group avr32/drivers/scif
    ../../../../scif/: scif_uc3c.c
  group avr32/drivers/usart
    ../../../../usart/: usart.c
  group avr32/boards/uc3c_ek
    ../../../../../boards/uc3c_ek/: led.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
  group common/services/clock/uc3c
    ../../../../../../common/services/clock/uc3c/: osc.c sysclk.c pll.c
  group common/services/sleepmgr/uc3
    ../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c
