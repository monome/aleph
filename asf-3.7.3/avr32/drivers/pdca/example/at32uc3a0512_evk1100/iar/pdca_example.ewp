# IAR project pdca_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../utils; ../../../../gpio; ../../../../../../common/services/clock; ../../../../../../common/boards; ..; ../../../../usart; ../../../../flashc; ../../../../pm; ../../../../../boards; ../../..; ../..; ../../../../../boards/evk1100; ../../../../../utils/preprocessor; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1100
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock/uc3a0_a1
    ../../../../../../common/services/clock/uc3a0_a1/: sysclk.c
  group common/services/sleepmgr/uc3
    ../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c
  group avr32/drivers/flashc
    ../../../../flashc/: flashc.c
  group avr32/drivers/pm
    ../../../../pm/: pm.c power_clocks_lib.c pm_conf_clocks.c
  group avr32/drivers/pdca
    ../../../: pdca.c
  group avr32/drivers/pdca/example
    ../../: pdca_example.c
  group avr32/drivers/usart
    ../../../../usart/: usart.c
  group avr32/boards/evk1100
    ../../../../../boards/evk1100/: led.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
