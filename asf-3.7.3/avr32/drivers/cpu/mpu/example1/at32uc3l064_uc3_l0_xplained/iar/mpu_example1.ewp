# IAR project mpu_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ..; ../../../../../../../common/services/clock; ../../../../../../utils/debug; ../../../../../../boards/uc3_l0_xplained; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../usart; ../../../../../scif; ../../../../../../boards; ../../../../../../utils; ../../../../cycle_counter; ../../../../../gpio; ../../../../../flashcdw; ../../../../../pm; ../../../../../../../common/utils; ../../../../../intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/scif
    ../../../../../scif/: scif_uc3l.c
  group avr32/drivers/pm
    ../../../../../pm/: pm_uc3l.c power_clocks_lib.c
  group avr32/drivers/gpio
    ../../../../../gpio/: gpio.c
  group avr32/drivers/flashcdw
    ../../../../../flashcdw/: flashcdw.c
  group avr32/drivers/cpu/mpu
    ../../../: mpu.c
  group avr32/drivers/cpu/mpu/example1
    ../../: mpu_example1.c mpu_exception.s82
  group avr32/drivers/intc
    ../../../../../intc/: intc.c
  group avr32/drivers/usart
    ../../../../../usart/: usart.c
  group avr32/utils/debug
    ../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/boards/uc3_l0_xplained
    ../../../../../../boards/uc3_l0_xplained/: led.c
  group common/services/clock/uc3l
    ../../../../../../../common/services/clock/uc3l/: dfll.c sysclk.c osc.c
