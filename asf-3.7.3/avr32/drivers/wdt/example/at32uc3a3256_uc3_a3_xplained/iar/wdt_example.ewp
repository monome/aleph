# IAR project wdt_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_A3_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../utils/preprocessor; ../../../../../../common/boards; ../../../../flashc; ../../../../../boards; ../../../../../utils; ../../../../cpu/cycle_counter; ../../../../gpio; ../../../../../../common/utils; ../../../../pm; ../../..; ../../../../../boards/uc3_a3_xplained; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_A3_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c
  group avr32/drivers/flashc
    ../../../../flashc/: flashc.c
  group avr32/drivers/pm
    ../../../../pm/: pm.c power_clocks_lib.c pm_conf_clocks.c
  group avr32/drivers/wdt
    ../../../: wdt.c
  group avr32/drivers/wdt/example
    ../../: wdt_example.c
  group avr32/boards/uc3_a3_xplained
    ../../../../../boards/uc3_a3_xplained/: led.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
