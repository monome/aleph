# IAR project usbb_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x4000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x6000
  ICCAVR32.CCDefines: BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../utils/preprocessor; ../../../../../../../services/usb/_asf_v1; ../../../../enum/device; ../../..; ../../../..; ../../../../../../../utils/debug; ../../../enum; ../../../../../../../../common/boards; ../../../../../../usart; ../../../../../../flashc; ../../../../../../pm; ../../../../../../../boards; ../../../../../../../utils; ../../../../../../cpu/cycle_counter; ../../../../../../../boards/evk1100; ../../../../../../gpio; ../../../enum/device; ../../../../enum; ../../../../../../../../common/utils; ../../../../../../intc; ../../../../enum/host; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1100
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/gpio
    ../../../../../../gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../../../usart/: usart.c
  group avr32/drivers/usbb/_asf_v1
    ../../../../: usb_drv.c
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../enum/: usb_task.c
  group avr32/drivers/usbb/_asf_v1/enum/host
    ../../../../enum/host/: usb_host_task.c usb_host_enum.c
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../enum/device/: usb_device_task.c usb_standard_request.c
  group avr32/drivers/usbb/_asf_v1/examples
    ../../../: enum_example.c device_template_task.c host_template_task.c
  group avr32/drivers/usbb/_asf_v1/examples/enum/device
    ../../../enum/device/: usb_descriptors.c usb_specific_request.c
  group avr32/drivers/pm
    ../../../../../../pm/: pm.c power_clocks_lib.c pm_conf_clocks.c
  group avr32/drivers/intc
    ../../../../../../intc/: intc.c exception.s82
  group avr32/drivers/flashc
    ../../../../../../flashc/: flashc.c
  group avr32/boards/evk1100
    ../../../../../../../boards/evk1100/: led.c
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82
