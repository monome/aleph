# IAR project tc_example3.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../flashc; ../../../../gpio; ../../../../../../common/services/clock; ../../../../../utils/debug; ../../..; ../../../../../../common/boards; ../../../../usart; ..; ../../../../../boards/evk1104; ../../../../../boards; ../../../../../utils; ../../../../../utils/preprocessor; ../../../../../../common/utils; ../../../../intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock/uc3a3_a4
    ../../../../../../common/services/clock/uc3a3_a4/: sysclk.c
  group avr32/drivers/flashc
    ../../../../flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../intc/: intc.c exception.s82
  group avr32/drivers/tc
    ../../../: tc.c
  group avr32/drivers/tc/example3
    ../../: tc_example3.c
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../usart/: usart.c
  group avr32/utils/debug
    ../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/boards/evk1104
    ../../../../../boards/evk1104/: led.c
