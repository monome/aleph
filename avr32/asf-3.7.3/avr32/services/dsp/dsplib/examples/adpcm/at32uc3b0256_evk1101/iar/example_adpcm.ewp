# IAR project example_adpcm.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1101; DSP_ADPCM; DSP_OPTIMIZATION=DSP_OPTI_SPEED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../utils/scripts/resampling_coefficients_generation/docsrc; ../../../../utils/programs/adpcm_encode/docsrc; ../../../../utils/scripts/adpcm_encoder/docsrc; ../../../../utils/scripts/print_complex_vect/docsrc; ../../../../../../../boards; ../../../../utils/programs/data_get/docsrc; ../../../../../../../drivers/pm; ../../../../utils/scripts/twiddle_factors_generator/docsrc; ../../../../include; ../../../../../../../utils; ../../../../../../../boards/evk1101; ../../../../../../../drivers/gpio; ../../../../utils/modules/debug; ../../../../../../../../common/utils; ../../../../at32uc; ../../../../utils/programs/adpcm_streaming/docsrc; ../../../../utils/scripts/serial_scope/docsrc; ../../../../../../../drivers/cpu/cycle_counter; ../../../../utils/scripts/print_real_vect/docsrc; ../../../../utils/programs/data_extract/docsrc; ../../../../utils/programs/data_print/docsrc; ../../../../utils/scripts/benchmark/docsrc; ../../../../../../../../common/boards; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../../../../../../utils/preprocessor; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101; DSP_ADPCM; DSP_OPTIMIZATION=DSP_OPTI_SPEED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/services/dsp/dsplib/utils/modules/debug
    ../../../../utils/modules/debug/: dsp_debug_read.c dsp_debug_print.c dsp_debug_printf.c
  group avr32/services/dsp/dsplib/utils/modules/debug/evk1101/usart1
    ../../../../utils/modules/debug/evk1101/usart1/: dsp_debug_setup_usart1_at32uc.c
  group avr32/services/dsp/dsplib/generic/advanced/adpcm
    ../../../../generic/advanced/adpcm/: adpcm.c
  group avr32/services/dsp/dsplib/examples/adpcm
    ../../: adpcm_example.c
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c
  group avr32/boards/evk1101
    ../../../../../../../boards/evk1101/: led.c
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82
