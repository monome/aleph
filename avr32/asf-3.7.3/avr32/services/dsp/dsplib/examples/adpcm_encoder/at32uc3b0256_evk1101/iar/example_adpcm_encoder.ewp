# IAR project example_adpcm_encoder.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1101; DSP_ADPCM; DSP_OPTIMIZATION=DSP_OPTI_SPEED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../utils/scripts/resampling_coefficients_generation/docsrc; ../../../../utils/programs/adpcm_encode/docsrc; ../../../../utils/scripts/adpcm_encoder/docsrc; ../../../../utils/scripts/print_complex_vect/docsrc; ../../../../../../../boards; ../../../../../../../drivers/pdca; ../../../../utils/programs/data_get/docsrc; ../../../../../../../drivers/pm; ../../../../utils/scripts/twiddle_factors_generator/docsrc; ../../../../../../../drivers/tc; ../../../../include; ../../../../../../../drivers/adc; ../../../../../../../utils; ../../../../../../../boards/evk1101; ../../../../../../../drivers/gpio; ../../../../../../../../common/utils; ../../../../at32uc; ../../../../../../../drivers/pwm; ../../../../utils/programs/adpcm_streaming/docsrc; ../../../../utils/scripts/serial_scope/docsrc; ../../../../../../../drivers/cpu/cycle_counter; ../../../../utils/scripts/print_real_vect/docsrc; ../../../../utils/programs/data_print/docsrc; ../../../../utils/programs/data_extract/docsrc; ../../../../utils/scripts/benchmark/docsrc; ../../../../../../../../common/boards; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../../../../../../utils/preprocessor; ../../../../../../../drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101; DSP_ADPCM; DSP_OPTIMIZATION=DSP_OPTI_SPEED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/boards/evk1101
    ../../../../../../../boards/evk1101/: led.c
  group avr32/services/dsp/dsplib/generic/advanced/adpcm
    ../../../../generic/advanced/adpcm/: adpcm.c
  group avr32/services/dsp/dsplib/examples/adpcm_encoder
    ../../: adpcm_example.c
  group avr32/drivers/adc
    ../../../../../../../drivers/adc/: adc.c
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/pwm
    ../../../../../../../drivers/pwm/: pwm.c
  group avr32/drivers/pdca
    ../../../../../../../drivers/pdca/: pdca.c
  group avr32/drivers/tc
    ../../../../../../../drivers/tc/: tc.c
  group avr32/drivers/intc
    ../../../../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82
