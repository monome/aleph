# IAR project adaptif_src_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0xD000
  ICCAVR32.CCDefines: BOARD=EVK1105; CONFIG_INTERRUPT_FORCE_INTC
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../../../thirdparty/newlib_addons/libs/include; ..; ../../../../../../hid; ../..; ../../../../../../../../../../boards; ../../../../../../../../../../drivers/pdca; ../../../../../../../../../../components/audio; ../../../../../../../../../../drivers/pm; ../../../enum/host; ../../../../../../../../../audio/audio_mixer; ../../../../../../../../../../utils/libs/dsplib/include; ../../../../../../../../../../components/display/et024006dhu; ../../../../../../..; ../../../../../../../../../../drivers/ssc/i2s; ../../../../../../../../../../drivers/usbb/_asf_v1; ../../../../../../../../../../utils/debug; ../../..; ../../../../../../../../../../boards/evk1105; ../../../../../../../../../../utils; ../../../../../../../../../../drivers/gpio; ../../../../../../../../../../components/audio/codec/tlv320aic23b; ../../../../../../../../../../../common/utils; ../../../../../../../../../audio/audio_player/players/usb; ../../../../../../../../../../components/audio/dac/pwm_dac; ../../../enum; ../../../../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../../../../drivers/usbb/_asf_v1/enum; ../../../conf; ../../../../../../../../../../drivers/usbb/_asf_v1/enum/host; ../../../../../../../../../../drivers/abdac; ../../../../../../../../../../drivers/ebi/smc; ../../../../../../../../../../../common/boards; ../../../../../../../../../../components/audio/amp/tpa6130a2; ../../../../../../../../../../drivers/usart; ../../../../../../../../../../drivers/flashc; ../../../../../../../../../../drivers/twi; ../../../../../../../../../../utils/preprocessor; ../../../../../../../../../../drivers/intc; ../../../../../../../../../../components/touch/qt1081; ../../../user_interface/controller; ../../../../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105; CONFIG_INTERRUPT_FORCE_INTC
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/utils/libs/dsplib/at32ucr2/iar
    ../../../../../../../../../../utils/libs/dsplib/at32ucr2/iar/: libdsp-at32ucr2-dspspeed_opt.r82
  group avr32/utils/debug
    ../../../../../../../../../../utils/debug/: print_funcs.c debug.c
  group avr32/utils/startup
    ../../../../../../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/services/usb/_asf_v1/class/audio/examples/host
    ../../../: audio_example.c avr32_logo.c host_audio_task.c
  group avr32/services/usb/_asf_v1/class/audio/examples/host/user_interface/controller
    ../../../user_interface/controller/: qt1081_controller.c
  group avr32/services/usb/_asf_v1/class/audio/examples/host/enum/host
    ../../../enum/host/: usb_host_user.c
  group avr32/services/audio/audio_player/players/usb
    ../../../../../../../../../audio/audio_player/players/usb/: usb_stream_player_with_resampling.c
  group avr32/services/audio/audio_mixer
    ../../../../../../../../../audio/audio_mixer/: audio_mixer.c
  group avr32/drivers/usbb/_asf_v1
    ../../../../../../../../../../drivers/usbb/_asf_v1/: usb_drv.c
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../../../../../../../drivers/usbb/_asf_v1/enum/: usb_task.c
  group avr32/drivers/usbb/_asf_v1/enum/host
    ../../../../../../../../../../drivers/usbb/_asf_v1/enum/host/: usb_host_enum.c usb_host_task.c
  group avr32/drivers/pdca
    ../../../../../../../../../../drivers/pdca/: pdca.c
  group avr32/drivers/usart
    ../../../../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../../../../../../drivers/flashc/: flashc.c
  group avr32/drivers/pm
    ../../../../../../../../../../drivers/pm/: pm_conf_clocks.c power_clocks_lib.c pm.c
  group avr32/drivers/abdac
    ../../../../../../../../../../drivers/abdac/: abdac.c
  group avr32/drivers/gpio
    ../../../../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../../../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/twi
    ../../../../../../../../../../drivers/twi/: twi.c
  group avr32/drivers/ssc/i2s
    ../../../../../../../../../../drivers/ssc/i2s/: ssc_i2s.c
  group avr32/drivers/ebi/smc
    ../../../../../../../../../../drivers/ebi/smc/: smc.c
  group avr32/components/audio/codec/tlv320aic23b
    ../../../../../../../../../../components/audio/codec/tlv320aic23b/: tlv320aic23b.c
  group avr32/components/audio/dac/pwm_dac
    ../../../../../../../../../../components/audio/dac/pwm_dac/: pwm_dac.c
  group avr32/components/audio/amp/tpa6130a2
    ../../../../../../../../../../components/audio/amp/tpa6130a2/: tpa6130.c
  group avr32/components/display/et024006dhu
    ../../../../../../../../../../components/display/et024006dhu/: et024006dhu.c
  group avr32/boards/evk1105
    ../../../../../../../../../../boards/evk1105/: led.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3
    ../../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3/: read.c write.c
