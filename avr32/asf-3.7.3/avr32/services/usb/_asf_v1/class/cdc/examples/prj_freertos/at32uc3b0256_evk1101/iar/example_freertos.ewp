# IAR project example_freertos.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x3D00
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x3D00
  ICCAVR32.CCDefines: BOARD=EVK1101; FREERTOS_USED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../drivers/usbb/_asf_v1/enum/device; ../../../../../../../../../components/joystick/skrhabe010; ../../freertos; ../../../../../../../../../boards; ../../../../../../../../../drivers/pm; ../../..; ../../../../../..; ../../../../../../../../../drivers/usbb/_asf_v1; ../../../../../../../../../utils/debug; ../../../../../../../../../drivers/tc; ../../../../../../../../../drivers/adc; ../../../../../../../../../utils; ../../../../../../../../../boards/evk1101; ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3; ../../../../../../../../../drivers/gpio; ../../../../../../../../../../common/utils; ../../../conf; ../../../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../../../../common/services/fifo; ../../../../../../../../../drivers/usbb/_asf_v1/enum; ../../../../../../../../../drivers/usbb/_asf_v1/enum/host; ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/include; ../../../../../../../../../../thirdparty/newlib_addons/libs/include; ../../../../../../../../../../common/boards; ../../../enum; ../../../../../../../../../drivers/usart; ../../../../../../../../../drivers/flashc; ../../../../../../../../../utils/preprocessor; ../../../../../../../../../drivers/intc; ../../../..; ../../../enum/device; ../../../../../../../../../components/accelerometer/lis3l06al; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1101; FREERTOS_USED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/utils/debug
    ../../../../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/boards/evk1101
    ../../../../../../../../../boards/evk1101/: led.c
  group avr32/components/accelerometer/lis3l06al
    ../../../../../../../../../components/accelerometer/lis3l06al/: lis3l06al.c
  group avr32/services/usb/_asf_v1/class/cdc/examples
    ../../../: cdc_example.c uart_usb_lib.c device_cdc_task.c host_cdc_task.c
  group avr32/services/usb/_asf_v1/class/cdc/examples/enum/device
    ../../../enum/device/: usb_descriptors.c usb_specific_request.c
  group avr32/drivers/flashc
    ../../../../../../../../../drivers/flashc/: flashc.c
  group avr32/drivers/usbb/_asf_v1
    ../../../../../../../../../drivers/usbb/_asf_v1/: usb_drv.c
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/: usb_task.c
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/device/: usb_device_task.c usb_standard_request.c
  group avr32/drivers/usbb/_asf_v1/enum/host
    ../../../../../../../../../drivers/usbb/_asf_v1/enum/host/: usb_host_task.c usb_host_enum.c
  group avr32/drivers/adc
    ../../../../../../../../../drivers/adc/: adc.c
  group avr32/drivers/intc
    ../../../../../../../../../drivers/intc/: intc.c
  group avr32/drivers/pm
    ../../../../../../../../../drivers/pm/: power_clocks_lib.c pm_conf_clocks.c pm.c
  group avr32/drivers/gpio
    ../../../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/tc
    ../../../../../../../../../drivers/tc/: tc.c
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/: timers.c croutine.c list.c queue.c tasks.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3
    ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/avr32_uc3/: port.c read.c write.c exception.s82
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/memmang/: heap_3.c
  group common/services/fifo
    ../../../../../../../../../../common/services/fifo/: fifo.c
