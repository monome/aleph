# IAR project pevc_example3.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../utils; ../..; ../../../../../utils/preprocessor; ../../../../../boards/uc3c_ek; ../../../../scif; ../../../../../utils/debug; ../../..; ../../../../twim; ../../../../../../common/boards; ../../../../usart; ../../../../flashc; ../../../../../boards; ../../../../pdca; ../../../../cpu/cycle_counter; ../../../../../components/touch/at42qt1060; ../../../../pm; ../../../../../../common/utils; ../../../../gpio; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/twim
    ../../../../twim/: twim.c
  group avr32/drivers/flashc
    ../../../../flashc/: flashc.c
  group avr32/drivers/pm
    ../../../../pm/: power_clocks_lib.c pm_uc3c.c
  group avr32/drivers/pevc
    ../../../: pevc.c
  group avr32/drivers/pevc/example3
    ../../: pevc_example3.c
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c
  group avr32/drivers/scif
    ../../../../scif/: scif_uc3c.c
  group avr32/drivers/usart
    ../../../../usart/: usart.c
  group avr32/drivers/pdca
    ../../../../pdca/: pdca.c
  group avr32/utils/debug
    ../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/components/touch/at42qt1060
    ../../../../../components/touch/at42qt1060/: at42qt1060.c
  group avr32/boards/uc3c_ek
    ../../../../../boards/uc3c_ek/: led.c
