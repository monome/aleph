# IAR project eic_example2.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../utils/preprocessor; ../../../../../../common/boards; ../../../../../boards/evk1104; ../../../../../boards; ../../../../../utils; ../../../../gpio; ../../../../../../common/utils; ../../../../intc; ..; ../../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/eic
    ../../../: eic.c
  group avr32/drivers/eic/example2
    ../../: eic_example2.c exception.s82
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../intc/: intc.c
  group avr32/boards/evk1104
    ../../../../../boards/evk1104/: led.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
