# IAR project sau_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3L_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../mpu; ../../../../../../utils/preprocessor; ..; ../../../../../scif; ../../../../../../utils/debug; ../../../../../../boards/uc3l_ek; ../../..; ../../../../../../../common/boards; ../../../../../usart; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../utils; ../../../../cycle_counter; ../../../../../../../common/utils; ../../../../../gpio; ../../../../../intc; ../../../../../pm; ../../../../../flashcdw; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3L_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/scif
    ../../../../../scif/: scif_uc3l.c
  group avr32/drivers/cpu/sau
    ../../../: sau.c
  group avr32/drivers/cpu/sau/example
    ../../: sau_example.c sau_exception.s82
  group avr32/drivers/cpu/mpu
    ../../../../mpu/: mpu.c
  group avr32/drivers/pm
    ../../../../../pm/: pm_uc3l.c power_clocks_lib.c
  group avr32/drivers/flashcdw
    ../../../../../flashcdw/: flashcdw.c
  group avr32/drivers/intc
    ../../../../../intc/: intc.c
  group avr32/drivers/gpio
    ../../../../../gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../../usart/: usart.c
  group avr32/utils/debug
    ../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/boards/uc3l_ek
    ../../../../../../boards/uc3l_ek/: led.c
  group common/services/clock/uc3l
    ../../../../../../../common/services/clock/uc3l/: dfll.c sysclk.c osc.c
