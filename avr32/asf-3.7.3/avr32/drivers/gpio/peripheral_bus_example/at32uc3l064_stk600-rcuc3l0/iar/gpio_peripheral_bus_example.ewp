# IAR project gpio_peripheral_bus_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=STK600_RCUC3L0
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../../../../../common/boards; ../../../../../boards; ../../../../../utils; ../../../../../utils/preprocessor; ../../../../../../common/utils; ..; ../../../../../boards/stk600/rcuc3l0; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=STK600_RCUC3L0
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/boards/stk600/rcuc3l0
    ../../../../../boards/stk600/rcuc3l0/: led.c
  group avr32/drivers/gpio
    ../../../: gpio.c
  group avr32/drivers/gpio/peripheral_bus_example
    ../../: gpio_peripheral_bus_example.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
