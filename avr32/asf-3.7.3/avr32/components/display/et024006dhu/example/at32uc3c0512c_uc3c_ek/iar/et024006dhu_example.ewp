# IAR project et024006dhu_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../../../../../utils/preprocessor; ../../../../../../boards/uc3c_ek; ../../../../../../drivers/scif; ../../../../../../../common/boards; ../../../../../../drivers/ebi/smc; ../../../../../../drivers/cpu/cycle_counter; ../../../../../../drivers/flashc; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../utils; ../../conf; ../../../../../../drivers/gpio; ../../../../../../drivers/intc; ../../../../../../drivers/pm; ../../../../../../../common/utils; ../../../../../../../common/services/delay; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/components/display/et024006dhu
    ../../../: et024006dhu.c
  group avr32/components/display/et024006dhu/example
    ../../: avr32_logo.c et024006dhu_example.c
  group avr32/drivers/intc
    ../../../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/scif
    ../../../../../../drivers/scif/: scif_uc3c.c
  group avr32/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c
  group avr32/drivers/pm
    ../../../../../../drivers/pm/: power_clocks_lib.c pm_uc3c.c
  group avr32/drivers/gpio
    ../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/flashc
    ../../../../../../drivers/flashc/: flashc.c
  group avr32/boards/uc3c_ek
    ../../../../../../boards/uc3c_ek/: led.c
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82
  group common/services/clock/uc3c
    ../../../../../../../common/services/clock/uc3c/: pll.c sysclk.c osc.c
