# IAR project qt1081_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../drivers/flashc; ../../../../../../drivers/gpio; ../../../../../../../common/boards; ../../../../../../boards/evk1105; ../../../../../../boards; ../../../../../../utils; ../../..; ../../../../../../utils/preprocessor; ../../../../../../drivers/intc; ../../../../../../drivers/pm; ../../../../../../../common/utils; ../../../../../../drivers/eic; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/gpio
    ../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/pm
    ../../../../../../drivers/pm/: pm_conf_clocks.c pm.c power_clocks_lib.c
  group avr32/drivers/eic
    ../../../../../../drivers/eic/: eic.c
  group avr32/drivers/flashc
    ../../../../../../drivers/flashc/: flashc.c
  group avr32/components/touch/qt1081/example
    ../../: qt1081_example.c
  group avr32/boards/evk1105
    ../../../../../../boards/evk1105/: led.c
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82
