# IAR project qt60168_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../../../../display/et024006dhu; ../../../../../../utils/preprocessor; ../../../../../../utils/debug; ../../../../../../drivers/ebi/smc; ../../../../../../../common/boards; ../../../../../../drivers/usart; ../../../../../../drivers/flashc; ../../../../../../boards/evk1104; ../../../../../../boards; ../../../../../../utils; ../../../../../../drivers/cpu/cycle_counter; ../../../../../../drivers/gpio; ../../../../../../drivers/pm; ../../../../../../../common/utils; ../../conf; ../../../../../../drivers/spi; ../../../../../../drivers/eic; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/components/touch/qt60168
    ../../../: qt60168.c
  group avr32/components/touch/qt60168/example
    ../../: qt60168_example.c
  group avr32/components/display/et024006dhu
    ../../../../../display/et024006dhu/: et024006dhu.c
  group avr32/drivers/pm
    ../../../../../../drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/eic
    ../../../../../../drivers/eic/: eic.c
  group avr32/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c
  group avr32/drivers/usart
    ../../../../../../drivers/usart/: usart.c
  group avr32/drivers/gpio
    ../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/spi
    ../../../../../../drivers/spi/: spi.c
  group avr32/drivers/flashc
    ../../../../../../drivers/flashc/: flashc.c
  group avr32/utils/debug
    ../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/boards/evk1104
    ../../../../../../boards/evk1104/: led.c
