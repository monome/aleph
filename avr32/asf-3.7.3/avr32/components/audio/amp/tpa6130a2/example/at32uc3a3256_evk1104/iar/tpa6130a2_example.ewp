# IAR project tpa6130a2_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../utils/preprocessor; ../../../../../../../drivers/ssc/i2s; ../../../../../../../drivers/abdac; ../../../../../../../utils/debug; ../../../../../../../drivers/twim; ../../../../../../../drivers/pdca; ../../..; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../../../../../../../common/boards; ../../../../../../../boards; ../../../../../../../utils; ../../../../..; ../../../../../../../boards/evk1104; ../../../../../../../drivers/gpio; ../../../../../../../drivers/intc; ../../../../../../../drivers/pm; ../../../../../../../../common/utils; ../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/components/audio/amp/tpa6130a2
    ../../../: tpa6130.c
  group avr32/components/audio/amp/tpa6130a2/example
    ../../: tpa6130_example.c
  group avr32/drivers/abdac
    ../../../../../../../drivers/abdac/: abdac.c
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/twim
    ../../../../../../../drivers/twim/: twim.c
  group avr32/drivers/intc
    ../../../../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/ssc/i2s
    ../../../../../../../drivers/ssc/i2s/: ssc_i2s.c
  group avr32/drivers/pdca
    ../../../../../../../drivers/pdca/: pdca.c
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: power_clocks_lib.c pm_conf_clocks.c pm.c
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/boards/evk1104
    ../../../../../../../boards/evk1104/: led.c
