# IAR project nand_flash_ebi_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../../../boards; ../../../../../../../drivers/pm; ../../../../../../../utils/debug; ../../../../../../../../common/services/serial; ../../../../../../../boards/evk1104; ../../../../../../../utils; ../../../../../../../drivers/gpio; ../../../../../../../../common/utils; ../../conf; ../../../../../../../drivers/ecchrs; ../../../../../../../../common/services/clock; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../../common/services/serial/uc3_usart; ../../../../../../../drivers/ebi/smc; ../../../../../../../../common/boards; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../..; ../../../../../../../utils/preprocessor; ../../../../../../../drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/components/memory/nand_flash/nand_flash_ebi
    ../../../: nf.c
  group avr32/components/memory/nand_flash/nand_flash_ebi/example
    ../../: nf_example.c
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/ebi/smc
    ../../../../../../../drivers/ebi/smc/: smc.c
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c
  group avr32/boards/evk1104
    ../../../../../../../boards/evk1104/: init.c led.c
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82
  group common/services/clock/uc3a3_a4
    ../../../../../../../../common/services/clock/uc3a3_a4/: sysclk.c
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
