# IAR project mt48lc16m16a2tg7e_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; BOARD=EVK1104; TEST_SUITE_DEFINE_ASSERT_MACRO
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../../../utils/preprocessor; ../../../../../../../../common/services/clock; ../../../../../../../../common/services/serial/uc3_usart; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../common/boards; ../../../../../../../drivers/ebi/sdramc; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../../../../../../boards/evk1104; ../../../../../../../boards; ../../../../../../../utils; ../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../drivers/gpio; ../../../../../../../utils/debug; ../../../../../../../drivers/pm; ../../../../../../../../common/utils; ../../../..; ../..; ../../../../../../../../common/services/serial; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/services/clock/uc3a3_a4
    ../../../../../../../../common/services/clock/uc3a3_a4/: sysclk.c
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: pm.c power_clocks_lib.c pm_conf_clocks.c
  group avr32/drivers/ebi/sdramc
    ../../../../../../../drivers/ebi/sdramc/: sdramc.c
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c
  group avr32/boards/evk1104
    ../../../../../../../boards/evk1104/: init.c led.c
  group avr32/components/memory/sdram/mt48lc16m16a2tg7e/unit_tests
    ../../: unit_tests.c main.c
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82
