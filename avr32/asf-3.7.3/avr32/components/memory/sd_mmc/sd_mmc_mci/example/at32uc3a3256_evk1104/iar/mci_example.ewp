# IAR project mci_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104; SD_MMC_MCI_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../drivers/gpio; ../../../../../../../utils/debug; ../../../../../../../drivers/mci/_asf_v1; ../../../../../../../../common/boards; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../../../../../../boards/evk1104; ../../../../../../../boards; ../../../../../../../utils; ../../../../../../../drivers/cpu/cycle_counter; ../../../../../../../utils/preprocessor; ../../conf; ../../../../../../../drivers/pm; ../../../../../../../../common/utils; ../../../../../../../drivers/intc; ../../..; ../../../../../../../../common/services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104; SD_MMC_MCI_ENABLE
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/components/memory/sd_mmc/sd_mmc_mci
    ../../../: sd_mmc_mci.c sd_mmc_mci_mem.c
  group avr32/components/memory/sd_mmc/sd_mmc_mci/example
    ../../: sd_mmc_mci_example.c
  group avr32/drivers/mci/_asf_v1
    ../../../../../../../drivers/mci/_asf_v1/: mci.c
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c
  group avr32/boards/evk1104
    ../../../../../../../boards/evk1104/: led.c
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82
  group common/services/storage/ctrl_access
    ../../../../../../../../common/services/storage/ctrl_access/: ctrl_access.c
