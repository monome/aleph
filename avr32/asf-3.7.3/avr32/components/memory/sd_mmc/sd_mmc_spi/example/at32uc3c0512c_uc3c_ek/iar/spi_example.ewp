# IAR project spi_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK; SD_MMC_SPI_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../drivers/gpio; ../../../../../../../boards/uc3c_ek; ../../../../../../../drivers/scif; ../../../../../../../utils/debug; ../../..; ../../../../../../../../common/boards; ../../../../../../../drivers/usart; ../../../../../../../drivers/flashc; ../../conf; ../../../../../../../boards; ../../../../../../../utils; ../../../../../../../utils/preprocessor; ../../../../../../../drivers/pdca; ../../../../../../../drivers/pm; ../../../../../../../../common/utils; ../../../../../../../drivers/intc; ../../../../../../../drivers/spi; ../../../../../../../../common/services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK; SD_MMC_SPI_ENABLE
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/scif
    ../../../../../../../drivers/scif/: scif_uc3c.c
  group avr32/drivers/gpio
    ../../../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/spi
    ../../../../../../../drivers/spi/: spi.c
  group avr32/drivers/pm
    ../../../../../../../drivers/pm/: pm_uc3c.c power_clocks_lib.c
  group avr32/drivers/intc
    ../../../../../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/pdca
    ../../../../../../../drivers/pdca/: pdca.c
  group avr32/drivers/usart
    ../../../../../../../drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../../../drivers/flashc/: flashc.c
  group avr32/components/memory/sd_mmc/sd_mmc_spi
    ../../../: sd_mmc_spi.c sd_mmc_spi_mem.c
  group avr32/components/memory/sd_mmc/sd_mmc_spi/example
    ../../: sd_mmc_spi_example.c
  group avr32/boards/uc3c_ek
    ../../../../../../../boards/uc3c_ek/: led.c
  group avr32/utils/debug
    ../../../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../../utils/startup/: trampoline_uc3.s82
  group common/services/storage/ctrl_access
    ../../../../../../../../common/services/storage/ctrl_access/: ctrl_access.c
