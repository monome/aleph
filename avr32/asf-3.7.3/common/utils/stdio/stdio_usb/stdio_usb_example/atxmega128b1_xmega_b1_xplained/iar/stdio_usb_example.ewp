# IAR project stdio_usb_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../services/usb/class/cdc; ../../../../../../services/usb/class/cdc/device; ../../../../../../services/usb/udc; ..; ../../../../../../services/gpio; ../..; ../../../../../../../xmega/boards/xmega_b1_xplained; ../../../../../../boards; ../../../../../../../xmega/utils/preprocessor; ../../../../../../services/clock; ../../../../../../../xmega/drivers/usb; ../../../../../../services/usb; ../../../../..; ../../../../../../../xmega/boards; ../../../../../../../xmega/drivers/nvm; ../../../../../../services/sleepmgr; ../../../../../../../xmega/drivers/sleep; ../../../../../../../xmega/utils; ../../../../../../../xmega/drivers/cpu; ../../../../../../services/ioport; ../../..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/drivers/nvm
    ../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usb
    ../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_b1_xplained
    ../../../../../../../xmega/boards/xmega_b1_xplained/: init.c
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../: stdio_usb.c
  group common/utils/stdio/stdio_usb/stdio_usb_example
    ../../: stdio_usb_example.c
  group common/services/usb/class/cdc/device
    ../../../../../../services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../services/sleepmgr/xmega/: sleepmgr.c
