# IAR project stdio_usb_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK; UDD_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../services/usb/class/cdc; ../../../../../../../avr32/drivers/flashc; ../../../../../../services/usb/class/cdc/device; ../../../../../../../avr32/utils/preprocessor; ../../../../../../../avr32/boards/uc3c_ek; ../../../../../../services/clock; ../../../../../../../avr32/drivers/scif; ../..; ../../../../../../boards; ../../../../../../services/usb; ../../../../../../../avr32/boards; ..; ../../../../../../services/usb/udc; ../../..; ../../../../../../../avr32/utils; ../../../../../../../avr32/drivers/usbc; ../../../../../../../avr32/drivers/pm; ../../../../../../services/sleepmgr; ../../../../..; ../../../../../../../avr32/drivers/gpio; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK; UDD_ENABLE
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/boards/uc3c_ek
    ../../../../../../../avr32/boards/uc3c_ek/: init.c led.c
  group avr32/drivers/scif
    ../../../../../../../avr32/drivers/scif/: scif_uc3c.c
  group avr32/drivers/pm
    ../../../../../../../avr32/drivers/pm/: pm_uc3c.c power_clocks_lib.c
  group avr32/drivers/flashc
    ../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usbc
    ../../../../../../../avr32/drivers/usbc/: usbc_device.c
  group avr32/drivers/gpio
    ../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/utils/startup
    ../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/sleepmgr/uc3
    ../../../../../../services/sleepmgr/uc3/: sleepmgr.c
  group common/services/usb/class/cdc/device
    ../../../../../../services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c
  group common/services/clock/uc3c
    ../../../../../../services/clock/uc3c/: sysclk.c pll.c osc.c
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../: stdio_usb.c
  group common/utils/stdio/stdio_usb/stdio_usb_example
    ../../: stdio_usb_example.c
