# IAR project stdio_serial_stdio_serial_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../..; ../../../../../../../xmega/boards/stk600/rc032x; ../../../../../../../xmega/drivers/pmic; ../../../../../../services/clock; ../../../../../../../xmega/drivers/cpu; ../../../../../../services/serial; ../../../../../../boards; ../../../../../../../xmega/utils/preprocessor; ../../../../../../../xmega/utils; ../../../../../../services/ioport; ../../../../../../../xmega/drivers/usart; ../../../../../../../xmega/boards; ../../../../..; ../../../../../../services/serial/xmega_usart; ../../../../../../services/gpio; ..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC032X; IOPORT_XMEGA_COMPAT
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_serial/stdio_serial_example
    ../../: stdio_serial_example.c
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c
  group xmega/boards/stk600/rc032x
    ../../../../../../../xmega/boards/stk600/rc032x/: init.c
  group xmega/drivers/usart
    ../../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s
