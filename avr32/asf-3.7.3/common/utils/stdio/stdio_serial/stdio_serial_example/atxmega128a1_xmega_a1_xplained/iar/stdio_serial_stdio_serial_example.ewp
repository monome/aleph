# IAR project stdio_serial_stdio_serial_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../..; ../../../../../../../xmega/drivers/pmic; ../../../../../../services/clock; ../../../../../../../xmega/drivers/cpu; ../../../../../../services/serial; ../../../../../../boards; ../../../../../../../xmega/utils/preprocessor; ../../../../../../../xmega/utils; ../../../../../../../xmega/boards/xmega_a1_xplained; ../../../../../../services/ioport; ../../../../../../../xmega/drivers/usart; ../../../../../../../xmega/boards; ../../../../..; ../../../../../../services/serial/xmega_usart; ../../../../../../services/gpio; ..; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_serial/stdio_serial_example
    ../../: stdio_serial_example.c
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c
  group xmega/boards/xmega_a1_xplained
    ../../../../../../../xmega/boards/xmega_a1_xplained/: init.c
  group xmega/drivers/usart
    ../../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s
