# IAR project membag_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../services/serial; ..; ../../../../../../xmega/drivers/pmic; ../../../../../services/clock; ../../../../../../xmega/drivers/cpu; ../../../../stdio/stdio_serial; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/utils; ../../../../../../xmega/boards/xmega_a1_xplained; ../../../../../services/serial/xmega_usart; ../../../../../../xmega/drivers/usart; ../../../../../../xmega/boards; ../../../../../../xmega/drivers/sleep; ../../../../../services/sleepmgr; ../../../..; ../../../../../services/gpio; ../../..; ../../../../../services/ioport; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/sleepmgr/xmega
    ../../../../../services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../services/clock/xmega/: sysclk.c
  group common/services/serial
    ../../../../../services/serial/: usart_serial.c
  group common/services/ioport/xmega
    ../../../../../services/ioport/xmega/: ioport_compat.c
  group common/utils/membag
    ../../../: membag.c
  group common/utils/membag/unit_tests
    ../../: unit_tests.c
  group common/utils/stdio
    ../../../../stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../unit_test/: suite.c
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a1_xplained
    ../../../../../../xmega/boards/xmega_a1_xplained/: init.c
