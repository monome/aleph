# IAR project mxt_example_hid_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; CONF_GFX_ILI9341_SDT028ATFT=1; UDD_ENABLE; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../services/spi/sam_spi; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../services/gfx; ../../../../../../services/twi; ..; ../..; ../../../../../../../sam/drivers/spi; ../../../../../../services/sleepmgr; ../../../../../../utils; ../../..; ../../../../../../services/usb/class/hid/device/mouse; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../../sam/drivers/udp; ../../../../../../services/gpio; ../../../../../../../sam/drivers/pdc; ../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../services/delay; ../../../../../display/ili9341; ../../../../../../../sam/utils; ../../../../../../services/usb/class/hid/device; ../../../../../../services/spi; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/boards/sam4s_xplained; ../../../../../../services/usb/class/hid; ../../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mxt_example_hid_flash.bin
  ILINK.IlinkOutputFile: mxt_example_hid_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/drivers/twi
    ../../../../../../../sam/drivers/twi/: twi.c
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/udp
    ../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c
  group sam/drivers/pdc
    ../../../../../../../sam/drivers/pdc/: pdc.c
  group sam/boards/sam4s_xplained
    ../../../../../../../sam/boards/sam4s_xplained/: led.c init.c
  group common/services/gfx
    ../../../../../../services/gfx/: sysfont.c gfx_text.c gfx_generic.c gfx_ili9341_sdt028atft.c
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c
  group common/services/usb/class/hid/device
    ../../../../../../services/usb/class/hid/device/: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../../../../services/usb/class/hid/device/mouse/: udi_hid_mouse.c udi_hid_mouse_desc.c
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c
  group common/services/sleepmgr/sam
    ../../../../../../services/sleepmgr/sam/: sleepmgr.c
  group common/services/clock/sam4s
    ../../../../../../services/clock/sam4s/: sysclk.c
  group common/components/touch/mxt
    ../../../: mxt_device.c
  group common/components/touch/mxt/example_hid
    ../../: example_hid.c ui.c
  group common/components/display/ili9341
    ../../../../../display/ili9341/: ili9341.c
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c
