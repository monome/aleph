# IAR project sd_mmc_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../..; ../../../../../../services/serial/sam_uart; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/boards/sam3x_ek; ../../../../../../../sam/utils/cmsis/sam3x/source/templates; ..; ../../../../../../services/serial; ../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../utils; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../sam/drivers/dmac; ../../../../../../services/gpio; ../../../../../../services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/hsmci; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_unit_tests_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/hsmci
    ../../../../../../../sam/drivers/hsmci/: hsmci.c
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/dmac
    ../../../../../../../sam/drivers/dmac/: dmac.c
  group sam/boards/sam3x_ek
    ../../../../../../../sam/boards/sam3x_ek/: init.c led.c
  group common/components/memory/sd_mmc
    ../../../: sd_mmc.c
  group common/components/memory/sd_mmc/unit_tests
    ../../: unit_tests.c
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../utils/unit_test/: suite.c
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c
  group common/services/clock/sam3x
    ../../../../../../services/clock/sam3x/: sysclk.c
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c
