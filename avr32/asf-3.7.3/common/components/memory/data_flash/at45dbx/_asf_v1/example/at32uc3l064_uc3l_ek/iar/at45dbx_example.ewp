# IAR project at45dbx_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3L_EK; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../../../avr32/drivers/scif; ../../../../../../../../../avr32/utils/debug; ../../../../../../../../../avr32/boards/uc3l_ek; ../../../../../../../../boards; ../../..; ../../../../../../../../../avr32/drivers/usart; ../../../../../../../../../avr32/boards; ../../../../../../../../../avr32/utils; ../../../../../../../../utils; ../../../../../../../../../avr32/utils/preprocessor; ../..; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../avr32/drivers/flashcdw; ../../../../../../../../../avr32/drivers/intc; ../../../../../../../../../avr32/drivers/spi; ../../../../../../../../services/storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3L_EK; AT45DBX_ENABLE
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/usart
    ../../../../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3l.c
  group avr32/drivers/flashcdw
    ../../../../../../../../../avr32/drivers/flashcdw/: flashcdw.c
  group avr32/drivers/scif
    ../../../../../../../../../avr32/drivers/scif/: scif_uc3l.c
  group avr32/drivers/intc
    ../../../../../../../../../avr32/drivers/intc/: intc.c exception.s82
  group avr32/drivers/spi
    ../../../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/utils/debug
    ../../../../../../../../../avr32/utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group avr32/boards/uc3l_ek
    ../../../../../../../../../avr32/boards/uc3l_ek/: led.c
  group common/components/memory/data_flash/at45dbx/_asf_v1
    ../../../: at45dbx.c at45dbx_mem.c
  group common/components/memory/data_flash/at45dbx/_asf_v1/example
    ../../: at45dbx_example.c
  group common/services/storage/ctrl_access
    ../../../../../../../../services/storage/ctrl_access/: ctrl_access.c
