# IAR project at45dbx_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../avr32/utils/preprocessor; ..; ../../../../../../../services/clock; ../../../../../../../../avr32/drivers/spi; ../../../../../../../services/spi; ../../../../../../../boards; ../../..; ../../../../../../../../avr32/drivers/flashc; ../../../../../../../../avr32/boards; ../../../../../../../../avr32/utils; ../../../../../../../../avr32/boards/evk1100; ../../../../../../../../avr32/drivers/gpio; ../../../../../../../utils; ../../../../../../../services/spi/uc3_spi; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1100
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/boards/evk1100
    ../../../../../../../../avr32/boards/evk1100/: led.c init.c
  group avr32/drivers/spi
    ../../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/drivers/flashc
    ../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/gpio
    ../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/utils/startup
    ../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/components/memory/data_flash/at45dbx
    ../../../: at45dbx.c
  group common/components/memory/data_flash/at45dbx/example
    ../../: at45dbx_example.c
  group common/services/clock/uc3a0_a1
    ../../../../../../../services/clock/uc3a0_a1/: sysclk.c
  group common/services/spi/uc3_spi
    ../../../../../../../services/spi/uc3_spi/: spi_master.c
