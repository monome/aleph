# IAR project at45dbx_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../xmega/drivers/pmic; ../../../../../../../services/clock; ..; ../../../../../../../services/spi; ../../../../../../../boards; ../../../../../../../services/ioport; ../../..; ../../../../../../../../xmega/utils; ../../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../xmega/drivers/usart; ../../../../../../../../xmega/drivers/cpu; ../../../../../../../../xmega/boards; ../../../../../../../../xmega/drivers/nvm; ../../../../../../../utils; ../../../../../../../services/gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/drivers/usart
    ../../../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/nvm
    ../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c
  group common/services/clock/xmega
    ../../../../../../../services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/spi/xmega_usart_spi
    ../../../../../../../services/spi/xmega_usart_spi/: usart_spi.c
  group common/components/memory/data_flash/at45dbx
    ../../../: at45dbx.c
  group common/components/memory/data_flash/at45dbx/example
    ../../: at45dbx_example.c
