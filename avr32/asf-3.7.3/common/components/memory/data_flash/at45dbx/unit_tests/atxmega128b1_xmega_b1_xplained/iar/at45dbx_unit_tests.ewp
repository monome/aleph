# IAR project at45dbx_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../xmega/boards/xmega_b1_xplained; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../xmega/drivers/pmic; ../../../../../../../services/clock; ../../../../../../../../xmega/drivers/cpu; ../../../../../../../services/spi; ../../../../../../../services/serial; ../../../../../../../boards; ../../../../../../../services/ioport; ../../..; ../../../../../../../../xmega/utils; ..; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../xmega/drivers/usart; ../../../../../../../../xmega/boards; ../../../../../../../../xmega/drivers/nvm; ../../../../../../../utils; ../../../../../../../services/serial/xmega_usart; ../../../../../../../services/gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/boards/xmega_b1_xplained
    ../../../../../../../../xmega/boards/xmega_b1_xplained/: init.c
  group xmega/drivers/usart
    ../../../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/nvm
    ../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s
  group common/services/clock/xmega
    ../../../../../../../services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c
  group common/services/spi/xmega_usart_spi
    ../../../../../../../services/spi/xmega_usart_spi/: usart_spi.c
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c
  group common/components/memory/data_flash/at45dbx
    ../../../: at45dbx.c
  group common/components/memory/data_flash/at45dbx/unit_tests
    ../../: unit_tests.c
