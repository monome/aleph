# IAR project at25dfx_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../../../services/serial/sam_uart; ../../../../../../../services/spi/sam_spi; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ..; ../../../../../../../../sam/utils/fpu; ../../../../../../../services/serial; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../utils; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../sam/utils/cmsis/sam4e/include; ../../../../../../../../sam/boards/sam4e_ek; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../services/spi; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../../services/ioport; ../../..; ../../../../../../../../sam/drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at25dfx_unit_tests_flash.bin
  ILINK.IlinkOutputFile: at25dfx_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c
  group common/services/spi/sam_spi
    ../../../../../../../services/spi/sam_spi/: spi_master.c
  group common/services/clock/sam4e
    ../../../../../../../services/clock/sam4e/: sysclk.c
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c
  group common/components/memory/serial_flash/at25dfx
    ../../../: at25dfx_hal_spi.c at25dfx.c
  group common/components/memory/serial_flash/at25dfx/unit_tests
    ../../: unit_tests.c
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam/boards/sam4e_ek
    ../../../../../../../../sam/boards/sam4e_ek/: init.c
