# IAR project at25dfx_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../services/serial/sam_uart; ../../../../../../../services/spi/sam_spi; ../../../../../../../boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../services/serial; ../../../../../../../../sam/drivers/spi; ../../../../../../../utils; ../../../../../../../../sam/boards/sam4l_ek; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ..; ../../../../../../../services/delay; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../../sam/drivers/flashcalw; ../../../../../../../services/ioport; ../../../../../../../../sam/drivers/bpm; ../../..; ../../../../../../../services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at25dfx_unit_tests_flash.bin
  ILINK.IlinkOutputFile: at25dfx_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c
  group common/services/spi/sam_spi
    ../../../../../../../services/spi/sam_spi/: spi_master.c
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c
  group common/services/clock/sam4l
    ../../../../../../../services/clock/sam4l/: dfll.c osc.c sysclk.c pll.c
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c
  group common/components/memory/serial_flash/at25dfx
    ../../../: at25dfx.c at25dfx_hal_spi.c
  group common/components/memory/serial_flash/at25dfx/unit_tests
    ../../: unit_tests.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/bpm
    ../../../../../../../../sam/drivers/bpm/: bpm.c
  group sam/drivers/flashcalw
    ../../../../../../../../sam/drivers/flashcalw/: flashcalw.c
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c
  group sam/boards/sam4l_ek
    ../../../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c
