# IAR project at25dfx_at25dfx_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ..; ../..; ../../../../../../../../sam/utils; ../../../../../../../../sam/utils/fpu; ../../../../../../../../sam/boards; ../../../../../../../services/spi; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../services/clock; ../../../../../../../services/ioport; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../../sam/utils/cmsis/sam4e/include; ../../../../../../../utils; ../../..; ../../../../../../../../sam/boards/sam4e_ek; ../../../../../../../services/spi/sam_spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at25dfx_at25dfx_example_flash.bin
  ILINK.IlinkOutputFile: at25dfx_at25dfx_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/services/spi/sam_spi
    ../../../../../../../services/spi/sam_spi/: spi_master.c
  group common/services/clock/sam4e
    ../../../../../../../services/clock/sam4e/: sysclk.c
  group common/components/memory/serial_flash/at25dfx
    ../../../: at25dfx_hal_spi.c at25dfx.c
  group common/components/memory/serial_flash/at25dfx/example
    ../../: at25dfx_example.c
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c
  group sam/boards/sam4e_ek
    ../../../../../../../../sam/boards/sam4e_ek/: init.c
