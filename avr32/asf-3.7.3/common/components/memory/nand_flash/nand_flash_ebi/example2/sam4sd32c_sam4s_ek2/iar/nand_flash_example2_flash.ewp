# IAR project nand_flash_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/header_files; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../../../sam/drivers/ebi/smc; ../../../../../../../services/serial; ../../../../../../../../sam/boards; ../../../../../../../utils; ../../../../../../../services/clock; ../../../../../../../../sam/drivers/matrix; ../../../../../../../utils/stdio/stdio_serial; ../../..; ../../../ftl_lib; ../../../../../../../../sam/boards/sam4s_ek2; ..; ../../../../../../../services/gpio; ../../../../../../../services/storage/ecc_hamming; ../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../services/delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../services/serial/sam_uart; ../../../../../../../boards; ../../../../../../../../sam/drivers/pio; ../../../../../../../services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nand_flash_example2_flash.bin
  ILINK.IlinkOutputFile: nand_flash_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../: nand_flash_raw_smc.c nand_flash_model.c nand_flash_spare_scheme.c nand_flash_ecc_sw.c
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib
    ../../../ftl_lib/: nand_flash_mem.c
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar
    ../../../ftl_lib/iar/: lib_nand_flash_cortexm4.a
  group common/components/memory/nand_flash/nand_flash_ebi/example2
    ../../: nand_flash_ecc_sw_example.c
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/services/clock/sam4s
    ../../../../../../../services/clock/sam4s/: sysclk.c
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c
  group common/services/storage/ecc_hamming
    ../../../../../../../services/storage/ecc_hamming/: ecc-sw.c
  group common/services/storage/ctrl_access
    ../../../../../../../services/storage/ctrl_access/: ctrl_access.c
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/ebi/smc
    ../../../../../../../../sam/drivers/ebi/smc/: smc.c
  group sam/drivers/matrix
    ../../../../../../../../sam/drivers/matrix/: matrix.c
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam/boards/sam4s_ek2
    ../../../../../../../../sam/boards/sam4s_ek2/: init.c led.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
