# IAR project ili9341_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_A3_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../services/delay; ../../..; ../../../../../../../avr32/drivers/gpio; ../../../../../../services/clock; ../../../../../../../avr32/drivers/spi; ../../../../../../services/spi; ..; ../../../../../../../avr32/drivers/pdca; ../../../../../../../avr32/boards; ../../../../../../boards; ../../../../../../../avr32/drivers/flashc; ../../../../../../services/ioport; ../../../../../../../avr32/utils; ../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../../avr32/utils/preprocessor; ../../../../../../utils; ../../../../../../services/spi/uc3_spi; ../../../../../../../avr32/boards/uc3_a3_xplained; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_A3_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/boards/uc3_a3_xplained
    ../../../../../../../avr32/boards/uc3_a3_xplained/: led.c init.c
  group avr32/drivers/flashc
    ../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/pdca
    ../../../../../../../avr32/drivers/pdca/: pdca.c
  group avr32/drivers/spi
    ../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/drivers/gpio
    ../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/utils/startup
    ../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/components/display/ili9341
    ../../../: ili9341.c
  group common/components/display/ili9341/example1_basic
    ../../: ili9341_example.c
  group common/services/spi/uc3_spi
    ../../../../../../services/spi/uc3_spi/: spi_master.c
  group common/services/clock/uc3a3_a4
    ../../../../../../services/clock/uc3a3_a4/: sysclk.c
