# IAR project ili9341_example1_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../services/delay; ../../..; ../../../../../../services/spi/sam_spi; ..; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../services/spi; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/spi; ../../../../../../../sam/drivers/pdc; ../../../../../../utils; ../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../services/gpio; ../../../../../../../sam/utils; ../../../../../../../sam/boards/sam4s_xplained; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ili9341_example1_flash.bin
  ILINK.IlinkOutputFile: ili9341_example1_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_xplained
    ../../../../../../../sam/boards/sam4s_xplained/: init.c led.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c
  group sam/drivers/pdc
    ../../../../../../../sam/drivers/pdc/: pdc.c
  group common/components/display/ili9341
    ../../../: ili9341.c
  group common/components/display/ili9341/example1_basic
    ../../: ili9341_example.c
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c
  group common/services/clock/sam4s
    ../../../../../../services/clock/sam4s/: sysclk.c
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c
