# IAR project sha204_example_client_host.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XMEGA_A1_XPLAINED; EXT_BOARD=SECURITY_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../xmega/drivers/pmic; ../../../../../../../../xmega/drivers/tc; ../../../../../../../../xmega/utils; ../../../..; ../../../../xmega_sha204; ../../../../../../../services/gpio; ../../../../../../../services/serial; ../../../../../../../services/ioport; ../../../../../../../services/serial/xmega_usart; ../../../../../../../../xmega/drivers/usart; ../../../../../../../services/sleepmgr; ../../../../../../../utils; ../../../example_utilities_log; ../../../../../../../services/clock; ../../../../../../../../xmega/boards/xmega_a1_xplained; ../..; ../../../../../../../../xmega/boards; ../../../../../../../services/twi; ../../../example_utilities_led; ../../../../../../../boards/security_xplained; ../../../../../../../../xmega/drivers/twi; ../../../../../../../boards; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../xmega/drivers/sleep; ../../../../../../../../xmega/drivers/cpu; ..; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1_XPLAINED; EXT_BOARD=SECURITY_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/components/crypto/sha204
    ../../../../: sha204_comm.c sha204_command_marshaling.c sha204_i2c.c
  group common/components/crypto/sha204/xmega_sha204
    ../../../../xmega_sha204/: sha204_timer.c
  group common/components/crypto/sha204/example/example_utilities_log
    ../../../example_utilities_log/: sha204_example_log.c
  group common/components/crypto/sha204/example/example_utilities_led
    ../../../example_utilities_led/: sha204_example_led.c
  group common/components/crypto/sha204/example/example_client_host
    ../../: sha204_example_client_host.c
  group common/boards/security_xplained
    ../../../../../../../boards/security_xplained/: security_xplained.c
  group common/services/clock/xmega
    ../../../../../../../services/clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../../services/sleepmgr/xmega/: sleepmgr.c
  group common/services/ioport/xmega
    ../../../../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c
  group xmega/boards/xmega_a1_xplained
    ../../../../../../../../xmega/boards/xmega_a1_xplained/: init.c
  group xmega/drivers/usart
    ../../../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/tc
    ../../../../../../../../xmega/drivers/tc/: tc.c
  group xmega/drivers/twi
    ../../../../../../../../xmega/drivers/twi/: twim.c twis.c
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s
