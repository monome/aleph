# IAR project nvm_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../services/clock; ../../../../../services/gpio; ../../../../../../xmega/boards/xmega_b1_xplained; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/utils; ../../../../../services/ioport; ../../..; ../../../../../../xmega/boards; ../../../../../../xmega/drivers/nvm; ..; ../../../../../utils; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_B1_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/clock/xmega
    ../../../../../services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../../services/ioport/xmega/: ioport_compat.c
  group common/drivers/nvm/xmega
    ../../../xmega/: xmega_nvm.c
  group common/drivers/nvm/example
    ../../: nvm_example.c
  group xmega/boards/xmega_b1_xplained
    ../../../../../../xmega/boards/xmega_b1_xplained/: init.c
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
