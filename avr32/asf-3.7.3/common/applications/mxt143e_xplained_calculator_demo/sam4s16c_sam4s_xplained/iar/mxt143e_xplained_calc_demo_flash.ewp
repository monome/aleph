# IAR project mxt143e_xplained_calc_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; CONF_GFX_ILI9341_SDT028ATFT=1; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../services/spi/sam_spi; ../../../../../sam/utils/preprocessor; ../../../../../sam/drivers/pmc; ../../../../../sam/utils/cmsis/sam4s/include; ../../../../services/gfx; ../..; ../../../../utils/membag; ../../../../../sam/drivers/spi; ../../../../../sam/drivers/pdc; ../../../../utils; ../../../../components/touch/mxt; ../../../../services/clock; ../../../../../sam/boards; ../../../../services/wtk; ../../../../services/gpio; ../../../../services/twi; ..; ../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../services/delay; ../../../../components/display/ili9341; ../../../../../sam/utils; ../../../../services/spi; ../../../../../sam/utils/header_files; ../../../../boards; ../../../../services/ioport; ../../../../../sam/drivers/pio; ../../../../../sam/boards/sam4s_xplained; ../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mxt143e_xplained_calc_demo_flash.bin
  ILINK.IlinkOutputFile: mxt143e_xplained_calc_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/wtk
    ../../../../services/wtk/: wtk_check_box.c wtk_button.c wtk_basic_frame.c win.c wtk_frame.c wtk_radio_button.c wtk_label.c wtk_progress_bar.c wtk_icon.c wtk_plot.c wtk.c wtk_slider.c
  group common/services/delay/sam
    ../../../../services/delay/sam/: cycle_counter.c
  group common/services/gfx
    ../../../../services/gfx/: gfx_generic.c gfx_text.c gfx_ili9341_sdt028atft.c sysfont.c
  group common/services/clock/sam4s
    ../../../../services/clock/sam4s/: sysclk.c
  group common/services/spi/sam_spi
    ../../../../services/spi/sam_spi/: spi_master.c
  group common/applications/mxt143e_xplained_calculator_demo
    ../../: widget_gui.c calculator.c
  group common/utils/interrupt
    ../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/membag
    ../../../../utils/membag/: membag.c
  group common/components/display/ili9341
    ../../../../components/display/ili9341/: ili9341.c
  group common/components/touch/mxt
    ../../../../components/touch/mxt/: mxt_device.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../sam/utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/drivers/spi
    ../../../../../sam/drivers/spi/: spi.c
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/twi
    ../../../../../sam/drivers/twi/: twi.c
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/pdc
    ../../../../../sam/drivers/pdc/: pdc.c
  group sam/boards/sam4s_xplained
    ../../../../../sam/boards/sam4s_xplained/: init.c led.c
