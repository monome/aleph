# IAR project mxt143e_xplained_calc_demo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../xmega/drivers/pmic; ../../../../../xmega/utils; ..; ../../../../services/gfx; ../..; ../../../../utils/membag; ../../../../services/ioport; ../../../../../xmega/drivers/usart; ../../../../../xmega/drivers/nvm; ../../../../utils; ../../../../components/touch/mxt; ../../../../services/clock; ../../../../services/wtk; ../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../xmega/boards; ../../../../services/gpio; ../../../../services/twi; ../../../../services/delay; ../../../../components/display/ili9341; ../../../../../xmega/drivers/twi; ../../../../services/spi; ../../../../boards; ../../../../../xmega/utils/preprocessor; ../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/wtk
    ../../../../services/wtk/: wtk_check_box.c wtk_button.c wtk_basic_frame.c win.c wtk_frame.c wtk_radio_button.c wtk_label.c wtk_progress_bar.c wtk_icon.c wtk_plot.c wtk.c wtk_slider.c
  group common/services/clock/xmega
    ../../../../services/clock/xmega/: sysclk.c
  group common/services/gfx
    ../../../../services/gfx/: gfx_generic.c gfx_ili9341_sdt028atft.c sysfont.c gfx_text.c
  group common/services/ioport/xmega
    ../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/spi/xmega_usart_spi
    ../../../../services/spi/xmega_usart_spi/: usart_spi.c
  group common/applications/mxt143e_xplained_calculator_demo
    ../../: widget_gui.c calculator.c
  group common/components/display/ili9341
    ../../../../components/display/ili9341/: ili9341.c
  group common/components/touch/mxt
    ../../../../components/touch/mxt/: mxt_device.c
  group common/utils/membag
    ../../../../utils/membag/: membag.c
  group xmega/drivers/nvm
    ../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/twi
    ../../../../../xmega/drivers/twi/: twis.c twim.c
  group xmega/drivers/usart
    ../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../xmega/boards/xmega_a3bu_xplained/: init.c
