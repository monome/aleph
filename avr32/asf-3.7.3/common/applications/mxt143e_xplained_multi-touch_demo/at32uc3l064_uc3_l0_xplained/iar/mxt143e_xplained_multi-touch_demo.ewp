# IAR project mxt143e_xplained_multi-touch_demo.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../avr32/boards; ../../../../services/spi/uc3_spi; ../../../../../avr32/drivers/twim; ../../../../services/gfx; ../../../../../avr32/utils; ../../../../../avr32/drivers/gpio; ../../../../utils; ../../../../../avr32/drivers/spi; ../../../../components/touch/mxt; ../../../../services/clock; ../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../avr32/drivers/flashcdw; ../../../../services/twi; ../..; ../../../../services/delay; ../../../../components/display/ili9341; ../../../../services/spi; ../../../../boards; ../../../../services/ioport; ../../../../../avr32/drivers/pdca; ../../../../../avr32/utils/preprocessor; ../../../../../avr32/boards/uc3_l0_xplained; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/gfx
    ../../../../services/gfx/: gfx_generic.c gfx_text.c gfx_ili9341_sdt028atft.c sysfont.c
  group common/services/clock/uc3l
    ../../../../services/clock/uc3l/: dfll.c osc.c sysclk.c
  group common/services/spi/uc3_spi
    ../../../../services/spi/uc3_spi/: spi_master.c
  group common/components/display/ili9341
    ../../../../components/display/ili9341/: ili9341.c
  group common/components/touch/mxt
    ../../../../components/touch/mxt/: mxt_device.c
  group common/applications/mxt143e_xplained_multi-touch_demo
    ../../: multi-touch_demo.c
  group avr32/drivers/pdca
    ../../../../../avr32/drivers/pdca/: pdca.c
  group avr32/drivers/twim
    ../../../../../avr32/drivers/twim/: twim.c
  group avr32/drivers/flashcdw
    ../../../../../avr32/drivers/flashcdw/: flashcdw.c
  group avr32/drivers/gpio
    ../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/spi
    ../../../../../avr32/drivers/spi/: spi.c
  group avr32/boards/uc3_l0_xplained
    ../../../../../avr32/boards/uc3_l0_xplained/: led.c init.c
  group avr32/utils/startup
    ../../../../../avr32/utils/startup/: trampoline_uc3.s82
