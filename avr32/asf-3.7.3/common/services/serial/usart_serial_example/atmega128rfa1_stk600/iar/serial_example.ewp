# IAR project serial_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_MEGA_RF
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: ../../../../../../mega/boards/stk600; ../../../megarf_usart; ../../../../../../mega/drivers/cpu; ../../../../../../mega/utils; ../../../../clock; ../../..; ../../../../../boards; ../../../../../../mega/boards/stk600/rc128x_rfx; ../../../../ioport; ../../../../../utils; ../..; ..; ../../../../gpio; ../../../../../../mega/drivers/usart; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_MEGA_RF
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_MEGA_RF
  group mega/drivers/usart
    ../../../../../../mega/drivers/usart/: usart_megarf.c
  group mega/boards/stk600/rc128x_rfx
    ../../../../../../mega/boards/stk600/rc128x_rfx/: init.c
  group common/services/serial
    ../../../: usart_serial.c
  group common/services/serial/usart_serial_example
    ../../: usart_serial_example.c
  group common/services/clock/mega
    ../../../../clock/mega/: sysclk.c
