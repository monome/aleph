# IAR project calendar_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../..; ../../../../clock; ../../../../gpio; ../../../../../boards; ../../../../ioport; ../../../../../../xmega/utils; ../../../../../../xmega/utils/preprocessor; ../..; ../../../../../../xmega/boards; ../../../../../utils; ../../../../../../xmega/boards/xplain; ../../../../../../xmega/drivers/cpu; ..; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
  group common/services/calendar
    ../../../: calendar.c
  group common/services/calendar/example1
    ../../: example1.c
  group xmega/boards/xplain
    ../../../../../../xmega/boards/xplain/: init.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
