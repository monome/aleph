# IAR project calendar_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../..; ../../..; ../../../../../../xmega/drivers/pmic; ../../../../clock; ../../../../gpio; ../../../../../utils/stdio/stdio_serial; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/utils; ../../../../ioport; ../../../../serial/xmega_usart; ..; ../../../../../../xmega/boards; ../../../../../utils; ../../../../../../xmega/drivers/usart; ../../../../../../xmega/boards/xplain; ../../../../../../xmega/drivers/cpu; ../../../../serial; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/services/calendar
    ../../../: calendar.c
  group common/services/calendar/unit_tests
    ../../: unit_tests.c
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
  group common/services/serial
    ../../../../serial/: usart_serial.c
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xplain
    ../../../../../../xmega/boards/xplain/: init.c
