# IAR project calendar_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../..; ../../../../../../avr32/drivers/gpio; ../../../../../../avr32/boards/uc3_l0_xplained; ../../../../clock; ../../../../serial/uc3_usart; ../../../../../utils/stdio/stdio_serial; ../../../../../boards; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/usart; ..; ../../../../../../avr32/utils; ../../../../../../avr32/utils/preprocessor; ../../../../../utils; ../../../../../../avr32/drivers/flashcdw; ../../../../serial; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock/uc3l
    ../../../../clock/uc3l/: osc.c sysclk.c dfll.c
  group common/services/calendar
    ../../../: calendar.c
  group common/services/calendar/unit_tests
    ../../: unit_tests.c
  group common/services/serial
    ../../../../serial/: usart_serial.c
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group avr32/drivers/flashcdw
    ../../../../../../avr32/drivers/flashcdw/: flashcdw.c
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/boards/uc3_l0_xplained
    ../../../../../../avr32/boards/uc3_l0_xplained/: init.c led.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
