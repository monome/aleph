# IAR project ioport_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: BOARD=ATMEGA256RFR2_XPLAINED_PRO
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../delay; ../../../../../../mega/drivers/cpu; ../../../../../../mega/utils; ../../../../clock; ../../../../../../mega/boards; ../../../../../boards; ../../..; ../..; ..; ../../../../../utils; ../../../../../../mega/boards/atmega256rfr2_xplained_pro; ../../../../gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=ATMEGA256RFR2_XPLAINED_PRO
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=ATMEGA256RFR2_XPLAINED_PRO
  group common/services/ioport/example1
    ../../: ioport_example1.c
  group common/services/clock/mega
    ../../../../clock/mega/: sysclk.c
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../../mega/boards/atmega256rfr2_xplained_pro/: init.c
