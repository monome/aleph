# IAR project ioport_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../delay; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ..; ../../../../../../sam/utils/preprocessor; ../..; ../../../../../../sam/utils/fpu; ../../..; ../../../../../../sam/drivers/pmc; ../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../sam/utils/cmsis/sam4e/include; ../../../../../utils; ../../../../../../sam/boards/sam4e_ek; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ioport_example2_flash.bin
  ILINK.IlinkOutputFile: ioport_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/boards/sam4e_ek
    ../../../../../../sam/boards/sam4e_ek/: init.c
  group common/services/ioport/example2
    ../../: ioport_example2.c
  group common/services/clock/sam4e
    ../../../../clock/sam4e/: sysclk.c
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
