# IAR project ioport_example3_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../sam/boards/sam4s_ek; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../..; ../../..; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ../../../../../utils; ..; ../../../../gpio; ../../../../../../sam/utils/cmsis/sam4s/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ioport_example3_flash.bin
  ILINK.IlinkOutputFile: ioport_example3_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_ek
    ../../../../../../sam/boards/sam4s_ek/: init.c led.c
  group common/services/ioport/example3
    ../../: ioport_example3.c
  group common/services/clock/sam4s
    ../../../../clock/sam4s/: sysclk.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
