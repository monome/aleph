# IAR project gfx_mono_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm32e5 ATxmega32E5
  ICCAVR.CCDefines: BOARD=XMEGA_E5_XPLAINED; GFX_MONO_UG_2832HSWEG04=1; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../delay; ../../../../../../xmega/drivers/pmic; ..; ../../../../../../xmega/drivers/cpu; ../../../../spi; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/utils; ../../..; ../../../../clock; ../../../../ioport; ../../../../../../xmega/drivers/usart; ../../../../../components/display/ssd1306; ../../../../../../xmega/boards; ../../../../../utils; ../../../../gpio; ../../../../../../xmega/boards/xmega_e5_xplained; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_E5_XPLAINED; GFX_MONO_UG_2832HSWEG04=1; IOPORT_XMEGA_COMPAT
  group common/components/display/ssd1306
    ../../../../../components/display/ssd1306/: ssd1306.c font.c
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
  group common/services/gfx_mono
    ../../../: gfx_mono_ug_2832hsweg04.c gfx_mono_framebuffer.c gfx_mono_generic.c
  group common/services/gfx_mono/example1
    ../../: example1.c
  group common/services/spi/xmega_usart_spi
    ../../../../spi/xmega_usart_spi/: usart_spi.c
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_e5_xplained
    ../../../../../../xmega/boards/xmega_e5_xplained/: init.c
