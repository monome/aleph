# IAR project example_spinctrl.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; GFX_MONO_C12832_A1Z=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../..; ../../../../delay; ../../../../../../xmega/drivers/pmic; ../../../../clock; ../../../../gpio; ../../../../spi; ../../../../../boards; ../../../../ioport; ..; ../../../../../../xmega/utils; ../../..; ../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/drivers/usart; ../../../../../../xmega/boards; ../../../../../../xmega/drivers/nvm; ../../../../../utils; ../../../../../../xmega/drivers/cpu; ../../../../../components/display/st7565r; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; GFX_MONO_C12832_A1Z=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/components/display/st7565r
    ../../../../../components/display/st7565r/: st7565r.c
  group common/services/gfx_mono
    ../../../: gfx_mono_c12832_a1z.c sysfont.c gfx_mono_framebuffer.c gfx_mono_generic.c gfx_mono_spinctrl.c gfx_mono_text.c
  group common/services/gfx_mono/example_spinctrl
    ../../: example_spinctrl.c
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
  group common/services/spi/xmega_usart_spi
    ../../../../spi/xmega_usart_spi/: usart_spi.c
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
