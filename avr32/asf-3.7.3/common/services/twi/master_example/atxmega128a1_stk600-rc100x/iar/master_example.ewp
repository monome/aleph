# IAR project master_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_RC100X; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../xmega/boards/stk600/rc100x; ..; ../../../../../../xmega/drivers/twi; ../../../../clock; ../../../../../../xmega/drivers/cpu; ../../../../../boards; ../../../../ioport; ../../../../../../xmega/utils; ../../../../../../xmega/utils/preprocessor; ../../../../gpio; ../../../../../../xmega/boards; ../../../../../utils; ../../..; ../..; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_RC100X; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC100X; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group xmega/boards/stk600/rc100x
    ../../../../../../xmega/boards/stk600/rc100x/: init.c
  group xmega/drivers/twi
    ../../../../../../xmega/drivers/twi/: twim.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
  group common/services/twi/master_example
    ../../: twi_master_example.c
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c
