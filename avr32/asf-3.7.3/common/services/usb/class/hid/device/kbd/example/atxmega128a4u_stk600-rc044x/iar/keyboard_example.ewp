# IAR project keyboard_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128a4u ATxmega128A4U
  ICCAVR.CCDefines: BOARD=STK600_RC044X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../clock; ../../../../../../../../../../xmega/drivers/usb; ../../../..; ../..; ../../../../../../../../../boards; ../../..; ../../../../../../../../../../xmega/drivers/nvm; ../../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../../xmega/utils; ..; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../xmega/boards; ../../../../../../../../../utils; ../../../../../../../../../../xmega/boards/stk600/rc044x; ../../../../..; ../../../../../../../../sleepmgr; ../../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../gpio; ../../../../../../../../../../xmega/drivers/cpu; ../../../../../../../../ioport; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC044X; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC044X; IOPORT_XMEGA_COMPAT
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/kbd
    ../../../: udi_hid_kbd_desc.c udi_hid_kbd.c
  group common/services/usb/class/hid/device/kbd/example
    ../../: main.c
  group common/services/usb/class/hid/device/kbd/example/atxmega128a4u_stk600-rc044x
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/clock/xmega
    ../../../../../../../../clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../../../sleepmgr/xmega/: sleepmgr.c
  group common/services/ioport/xmega
    ../../../../../../../../ioport/xmega/: ioport_compat.c
  group xmega/drivers/usb
    ../../../../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/nvm
    ../../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/stk600/rc044x
    ../../../../../../../../../../xmega/boards/stk600/rc044x/: init.c
