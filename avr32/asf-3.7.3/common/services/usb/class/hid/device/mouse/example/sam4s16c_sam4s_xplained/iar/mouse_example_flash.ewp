# IAR project mouse_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; UDD_ENABLE; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../..; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../..; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam/drivers/udp; ../../../../../../../../gpio; ../../../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ..; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../boards; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pio; ../../../../../../../../../../sam/boards/sam4s_xplained; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_example_flash.bin
  ILINK.IlinkOutputFile: mouse_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse.c udi_hid_mouse_desc.c
  group common/services/usb/class/hid/device/mouse/example
    ../../: main.c
  group common/services/usb/class/hid/device/mouse/example/sam4s16c_sam4s_xplained
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/clock/sam4s
    ../../../../../../../../clock/sam4s/: sysclk.c
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/drivers/udp
    ../../../../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/boards/sam4s_xplained
    ../../../../../../../../../../sam/boards/sam4s_xplained/: led.c init.c
