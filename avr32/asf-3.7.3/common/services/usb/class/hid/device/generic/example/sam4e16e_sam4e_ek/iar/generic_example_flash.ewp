# IAR project generic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; UDD_ENABLE; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pio; ../../..; ../../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../../sam/utils/fpu; ../../../../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../udc; ../..; ../../../../../../../../../../sam/drivers/udp; ../../../../../../../../../../sam/utils/cmsis/sam4e/include; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../boards; ../../../../../../..; ../../../../../../../../ioport; ..; ../../../../..; ../../../../../../../../../../sam/boards/sam4e_ek; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; UDD_ENABLE; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generic_example_flash.bin
  ILINK.IlinkOutputFile: generic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/boards/sam4e_ek
    ../../../../../../../../../../sam/boards/sam4e_ek/: init.c
  group sam/drivers/udp
    ../../../../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/generic
    ../../../: udi_hid_generic.c udi_hid_generic_desc.c
  group common/services/usb/class/hid/device/generic/example
    ../../: main.c
  group common/services/usb/class/hid/device/generic/example/sam4e16e_sam4e_ek
    ../: ui.c
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/clock/sam4e
    ../../../../../../../../clock/sam4e/: sysclk.c
