# IAR project mouse_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: UHD_ENABLE; BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../../../sam/drivers/usbc; ..; ../..; ../../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../../../../sam/drivers/eic; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam/boards/sam4l_ek; ../../../../../../../uhc; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../..; ../../../../../../../../../../sam/drivers/gpio; ../../../../../../../../delay; ../../../../../../../../../../sam/utils; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../../boards; ../../../../../../../../ioport; ../../../../..; ../../../../../../../../../../sam/drivers/bpm; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: UHD_ENABLE; BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_example_flash.bin
  ILINK.IlinkOutputFile: mouse_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x200
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam4l
    ../../../../../../../../clock/sam4l/: sysclk.c pll.c osc.c dfll.c
  group common/services/delay/sam
    ../../../../../../../../delay/sam/: cycle_counter.c
  group common/services/usb/class/hid/host/mouse
    ../../../: uhi_hid_mouse.c
  group common/services/usb/class/hid/host/mouse/example
    ../../: main.c
  group common/services/usb/class/hid/host/mouse/example/sam4lc4c_sam4l_ek
    ../: ui.c
  group common/services/usb/uhc
    ../../../../../../../uhc/: uhc.c
  group common/services/sleepmgr/sam4l
    ../../../../../../../../sleepmgr/sam4l/: sleepmgr.c
  group sam/drivers/gpio
    ../../../../../../../../../../sam/drivers/gpio/: gpio.c
  group sam/drivers/usbc
    ../../../../../../../../../../sam/drivers/usbc/: usbc_host.c
  group sam/drivers/flashcalw
    ../../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c
  group sam/drivers/eic
    ../../../../../../../../../../sam/drivers/eic/: eic.c
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/bpm
    ../../../../../../../../../../sam/drivers/bpm/: bpm.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/boards/sam4l_ek
    ../../../../../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c
