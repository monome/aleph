# IAR project example_hids_cdc_msc_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ACCESS_USB_ENABLED; UDD_ENABLE; VIRTUAL_MEMORY_ENABLE; __SAM4SD32C__; ARM_MATH_CM4=true; BOARD=SAM4S_EK2
  ICCARM.CCIncludePath2: ../../../../../cdc/device; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pmc; ../../../../../msc; ../../../../../../../../../sam/utils/cmsis/sam4s/include; ../..; ../../../../../../../../components/memory/virtual_mem; ..; ../../../../../hid/device/kbd; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../cdc; ../../../../../hid/device/mouse; ../../../../../msc/device; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/udp; ../../../../../../../gpio; ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../../../sam/boards/sam4s_ek2; ../../../../../../../../../sam/utils; ../../../../../hid/device; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pio; ../../../../../hid; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_hids_cdc_msc_flash.bin
  ILINK.IlinkOutputFile: example_hids_cdc_msc_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/udp
    ../../../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/boards/sam4s_ek2
    ../../../../../../../../../sam/boards/sam4s_ek2/: led.c init.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/usb/class/hid/device
    ../../../../../hid/device/: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../../../hid/device/mouse/: udi_hid_mouse.c
  group common/services/usb/class/hid/device/kbd
    ../../../../../hid/device/kbd/: udi_hid_kbd.c
  group common/services/usb/class/cdc/device
    ../../../../../cdc/device/: udi_cdc.c
  group common/services/usb/class/composite/device
    ../../../: udi_composite_desc.c
  group common/services/usb/class/composite/device/example2
    ../../: uart_sam.c memories_initialization_sam.c main.c
  group common/services/usb/class/composite/device/example2/sam4sd32c_sam4s_ek2
    ../: ui.c
  group common/services/usb/class/msc/device
    ../../../../../msc/device/: udi_msc.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/clock/sam4s
    ../../../../../../../clock/sam4s/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c
