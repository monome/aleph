# IAR project example_hidms_msc_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; ACCESS_USB_ENABLED; UDD_ENABLE; BOARD=SAM4S_EK; VIRTUAL_MEMORY_ENABLE; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..; ../../../../../../../../../sam/utils/preprocessor; ../../../../../msc; ../..; ../../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../hid/device/mouse; ../../../../../msc/device; ../../../../../../../../../sam/boards/sam4s_ek; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/drivers/udp; ../../../../../../../gpio; ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../../../sam/utils; ../../../../../hid/device; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pmc; ../../../../../hid; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_hidms_msc_flash.bin
  ILINK.IlinkOutputFile: example_hidms_msc_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/udp
    ../../../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/boards/sam4s_ek
    ../../../../../../../../../sam/boards/sam4s_ek/: led.c init.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/usb/class/hid/device
    ../../../../../hid/device/: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../../../hid/device/mouse/: udi_hid_mouse.c
  group common/services/usb/class/composite/device
    ../../../: udi_composite_desc.c
  group common/services/usb/class/composite/device/example1
    ../../: memories_initialization_sam.c main.c
  group common/services/usb/class/composite/device/example1/sam4s16c_sam4s_ek
    ../: ui.c
  group common/services/usb/class/msc/device
    ../../../../../msc/device/: udi_msc.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/clock/sam4s
    ../../../../../../../clock/sam4s/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c
