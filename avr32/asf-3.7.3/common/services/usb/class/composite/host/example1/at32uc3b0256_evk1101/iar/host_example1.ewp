# IAR project host_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: UHD_ENABLE; BOARD=EVK1101; ACCESS_MEM_TO_RAM_ENABLED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../hid/host/mouse; ../../../../../../../../../avr32/services/fs/fat; ../../../../../../../../../avr32/components/joystick/skrhabe010; ../../../../../../../../../avr32/boards; ../../../../../msc; ../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../avr32/drivers/eic; ../..; ../../../../../../../../../avr32/drivers/adc; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/boards/evk1101; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../avr32/utils/preprocessor; ../../../../../../uhc; ../../../../../../../clock; ../../../../../..; ../../../../../msc/host; ../../../../../../../../../avr32/components/accelerometer/lis3l06al; ../../../../../../../../boards; ../../../../../../../../../avr32/drivers/flashc; ..; ../../../../../hid; ../../../../../../../storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: UHD_ENABLE; BOARD=EVK1101; ACCESS_MEM_TO_RAM_ENABLED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/services/fs/fat
    ../../../../../../../../../avr32/services/fs/fat/: navigation.c fat_unusual.c file.c fat.c
  group avr32/drivers/eic
    ../../../../../../../../../avr32/drivers/eic/: eic.c
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c
  group avr32/drivers/usbb
    ../../../../../../../../../avr32/drivers/usbb/: usbb_host.c
  group avr32/drivers/adc
    ../../../../../../../../../avr32/drivers/adc/: adc.c
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/components/accelerometer/lis3l06al
    ../../../../../../../../../avr32/components/accelerometer/lis3l06al/: lis3l06al.c
  group avr32/boards/evk1101
    ../../../../../../../../../avr32/boards/evk1101/: init.c led.c
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/usb/class/hid/host/mouse
    ../../../../../hid/host/mouse/: uhi_hid_mouse.c
  group common/services/usb/class/msc/host
    ../../../../../msc/host/: uhi_msc.c uhi_msc_mem.c
  group common/services/usb/class/composite/host/example1
    ../../: main.c
  group common/services/usb/class/composite/host/example1/at32uc3b0256_evk1101
    ../: ui.c
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/clock/uc3b0_b1
    ../../../../../../../clock/uc3b0_b1/: sysclk.c
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c
