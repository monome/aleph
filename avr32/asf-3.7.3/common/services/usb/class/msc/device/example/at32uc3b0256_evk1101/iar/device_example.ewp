# IAR project device_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: ACCESS_USB_ENABLED; SD_MMC_ENABLE; UDD_ENABLE; BOARD=EVK1101; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../components/memory/sd_mmc; ../..; ../../../../../../../../components/memory/data_flash/at45dbx; ../../../../../../../../../avr32/boards; ../../../..; ../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../avr32/drivers/pm; ..; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/boards/evk1101; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../avr32/drivers/spi; ../../..; ../../../../../../../clock; ../../../../../../udc; ../../../../../..; ../../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../../delay; ../../../../../../../spi; ../../../../../../../../boards; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../../ioport; ../../../../../../../spi/uc3_spi; ../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/example
    ../../: memories_initialization_uc3.c main.c
  group common/services/usb/class/msc/device/example/at32uc3b0256_evk1101
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/clock/uc3b0_b1
    ../../../../../../../clock/uc3b0_b1/: sysclk.c
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c
  group common/services/spi/uc3_spi
    ../../../../../../../spi/uc3_spi/: spi_master.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../../../../components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c
  group common/components/memory/sd_mmc
    ../../../../../../../../components/memory/sd_mmc/: sd_mmc_spi.c sd_mmc_mem.c sd_mmc.c
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c
  group avr32/drivers/spi
    ../../../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/usbb
    ../../../../../../../../../avr32/drivers/usbb/: usbb_device.c
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/boards/evk1101
    ../../../../../../../../../avr32/boards/evk1101/: init.c led.c
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
