# IAR project device_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; _ASSERT_ENABLE_; ACCESS_USB_ENABLED; UDD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; VIRTUAL_MEMORY_ENABLE; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/drivers/usbc; ../../../../../../../../../sam/utils/preprocessor; ../../../..; ../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../serial; ..; ../../../../../../../../../sam/drivers/eic; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam/boards/sam4l_ek; ../../..; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/gpio; ../..; ../../../../../../../delay; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/usart; ../../../../../../../serial/sam_uart; ../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/bpm; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_unit_tests_flash.bin
  ILINK.IlinkOutputFile: device_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/clock/sam4l
    ../../../../../../../clock/sam4l/: pll.c dfll.c sysclk.c osc.c
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c
  group common/services/sleepmgr/sam4l
    ../../../../../../../sleepmgr/sam4l/: sleepmgr.c
  group common/services/delay/sam
    ../../../../../../../delay/sam/: cycle_counter.c
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c
  group sam/boards/sam4l_ek
    ../../../../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c
  group sam/drivers/flashcalw
    ../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/gpio
    ../../../../../../../../../sam/drivers/gpio/: gpio.c
  group sam/drivers/usbc
    ../../../../../../../../../sam/drivers/usbc/: usbc_device.c
  group sam/drivers/eic
    ../../../../../../../../../sam/drivers/eic/: eic.c
  group sam/drivers/bpm
    ../../../../../../../../../sam/drivers/bpm/: bpm.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
