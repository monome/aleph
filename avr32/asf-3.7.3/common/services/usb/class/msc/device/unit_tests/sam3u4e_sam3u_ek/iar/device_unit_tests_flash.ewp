# IAR project device_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; ACCESS_USB_ENABLED; SD_MMC_ENABLE; UDD_ENABLE; __SAM3U4E__; TEST_SUITE_DEFINE_ASSERT_MACRO; VIRTUAL_MEMORY_ENABLE; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../../../components/memory/sd_mmc; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pmc; ../../../..; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../../sam/drivers/ebi/smc; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../serial; ../../../../../../../sleepmgr; ../../../../../../../../utils; ..; ../../..; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../../../../sam/drivers/udphs; ../../../../../../../../../sam/boards/sam3u_ek; ../../../../../../../../../sam/drivers/dmac; ../../../../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../..; ../..; ../../../../../../../gpio; ../../../../../../../delay; ../../../../../../../../../sam/drivers/uart; ../../../../../../../../../sam/utils; ../../../../../../udc; ../../../../../../../../../sam/drivers/usart; ../../../../../../../serial/sam_uart; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/drivers/hsmci; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_unit_tests_flash.bin
  ILINK.IlinkOutputFile: device_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c
  group common/services/delay/sam
    ../../../../../../../delay/sam/: cycle_counter.c
  group common/services/clock/sam3u
    ../../../../../../../clock/sam3u/: sysclk.c
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/components/memory/sd_mmc
    ../../../../../../../../components/memory/sd_mmc/: sd_mmc_mem.c sd_mmc.c
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/uart
    ../../../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/ebi/smc
    ../../../../../../../../../sam/drivers/ebi/smc/: smc.c
  group sam/drivers/udphs
    ../../../../../../../../../sam/drivers/udphs/: udphs_device.c
  group sam/drivers/hsmci
    ../../../../../../../../../sam/drivers/hsmci/: hsmci.c
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/dmac
    ../../../../../../../../../sam/drivers/dmac/: dmac.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/: exceptions.c system_sam3u.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/boards/sam3u_ek
    ../../../../../../../../../sam/boards/sam3u_ek/: init.c led.c
