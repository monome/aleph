# IAR project device_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128a4u ATxmega128A4U
  ICCAVR.CCDefines: ACCESS_USB_ENABLED; IOPORT_XMEGA_COMPAT; BOARD=STK600_RC044X; AT45DBX_ENABLE
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../spi/xmega_spi; ../..; ../../../../../../../../components/memory/data_flash/at45dbx; ../../../../../../../../../xmega/utils; ../../../../../../../../../xmega/boards/stk600/rc044x; ../../../..; ../../../../../../../ioport; ../../../../../../../../../xmega/drivers/nvm; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../../../clock; ..; ../../../../../../udc; ../../../../../..; ../../../../../../../../../xmega/boards; ../../../../../../../gpio; ../../../../../../../../../xmega/drivers/usb; ../../../../../../../spi; ../../../../../../../../boards; ../../../../../../../../../xmega/drivers/spi; ../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../../xmega/drivers/cpu; ../../../../../../../storage/ctrl_access; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; ACCESS_USB_ENABLED; IOPORT_XMEGA_COMPAT; BOARD=STK600_RC044X; AT45DBX_ENABLE
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/example
    ../../: main.c memories_initialization_xmega.c
  group common/services/usb/class/msc/device/example/atxmega128a4u_stk600-rc044x
    ../: ui.c
  group common/services/ioport/xmega
    ../../../../../../../ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../../clock/xmega/: sysclk.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/sleepmgr/xmega
    ../../../../../../../sleepmgr/xmega/: sleepmgr.c
  group common/services/spi/xmega_spi
    ../../../../../../../spi/xmega_spi/: spi_master.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../../../../components/memory/data_flash/at45dbx/: at45dbx_mem.c at45dbx.c
  group xmega/drivers/usb
    ../../../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/nvm
    ../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/spi
    ../../../../../../../../../xmega/drivers/spi/: spi.c
  group xmega/drivers/cpu
    ../../../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/stk600/rc044x
    ../../../../../../../../../xmega/boards/stk600/rc044x/: init.c
