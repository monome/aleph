# IAR project device_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK; _ASSERT_ENABLE_; ACCESS_USB_ENABLED; SD_MMC_ENABLE; UDD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; VIRTUAL_MEMORY_ENABLE; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../components/memory/sd_mmc; ../../../../../../../../../avr32/drivers/scif; ../../../../../../../../components/memory/data_flash/at45dbx; ../../../../../../../../../avr32/boards; ../../../../../../../spi/uc3_spi; ../../../../../../../../../avr32/drivers/usbc; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../serial; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../avr32/drivers/spi; ../../..; ../../../../../../../clock; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../udc; ../../../../../..; ../../../../../../../../../avr32/drivers/cpu/cycle_counter; ../..; ../../../../../../../delay; ../../../../../../../../../avr32/boards/uc3c_ek; ../../../../../../../serial/uc3_usart; ../../../../../../../spi; ../../../../../../../../boards; ../../../../../../../../../avr32/drivers/usart; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../../ioport; ../../../..; ../../../../../../../../../avr32/utils/preprocessor; ..; ../../../../../../../storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/clock/uc3c
    ../../../../../../../clock/uc3c/: pll.c sysclk.c osc.c
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/unit_tests
    ../../: memories_initialization_uc3.c unit_tests.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c
  group common/services/spi/uc3_spi
    ../../../../../../../spi/uc3_spi/: spi_master.c
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../../../../components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c
  group common/components/memory/sd_mmc
    ../../../../../../../../components/memory/sd_mmc/: sd_mmc_spi.c sd_mmc_mem.c sd_mmc.c
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c
  group avr32/boards/uc3c_ek
    ../../../../../../../../../avr32/boards/uc3c_ek/: init.c led.c
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3c.c
  group avr32/drivers/spi
    ../../../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/usart
    ../../../../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/usbc
    ../../../../../../../../../avr32/drivers/usbc/: usbc_device.c
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/scif
    ../../../../../../../../../avr32/drivers/scif/: scif_uc3c.c
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
