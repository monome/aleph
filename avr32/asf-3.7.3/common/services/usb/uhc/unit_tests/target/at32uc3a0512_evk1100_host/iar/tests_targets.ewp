# IAR project tests_targets.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; UHD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../class/hid/host/mouse; ../../../../../../../../avr32/boards; ../../../../../../../../avr32/drivers/usbb; ../../../../../../../../avr32/drivers/pm; ../../../../../../serial; ..; ../../../../../../../../avr32/utils; ../../../../../../../../avr32/boards/evk1100; ../../../../../../../../avr32/drivers/gpio; ../../../../../../sleepmgr; ../../../../../../../utils; ../../../..; ../../../../../../clock; ../../../../../../../utils/stdio/stdio_serial; ../..; ../../../../..; ../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../delay; ../../../../../../serial/uc3_usart; ../../../../../../../boards; ../../../../../../../../avr32/drivers/usart; ../../../../../../../../avr32/drivers/flashc; ../../../../../../../../avr32/utils/preprocessor; ../../../../../class/hid; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/pm
    ../../../../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/usart
    ../../../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/flashc
    ../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usbb
    ../../../../../../../../avr32/drivers/usbb/: usbb_host.c
  group avr32/drivers/gpio
    ../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/boards/evk1100
    ../../../../../../../../avr32/boards/evk1100/: init.c led.c
  group avr32/utils/startup
    ../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/sleepmgr/uc3
    ../../../../../../sleepmgr/uc3/: sleepmgr.c
  group common/services/serial
    ../../../../../../serial/: usart_serial.c
  group common/services/usb/uhc
    ../../../../: uhc.c
  group common/services/usb/uhc/unit_tests/target
    ../../: unit_tests.c
  group common/services/usb/class/hid/host/mouse
    ../../../../../class/hid/host/mouse/: uhi_hid_mouse.c
  group common/services/clock/uc3a0_a1
    ../../../../../../clock/uc3a0_a1/: sysclk.c
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c
