# IAR project tests_targets_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; _ASSERT_ENABLE_; UHD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/header_files; ../../../../../class/hid/host/mouse; ../../../../../../../../sam/drivers/usbc; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../serial; ../../../../../../../../sam/drivers/eic; ../../../../../../sleepmgr; ../../../../../../../utils; ..; ../../../..; ../../../../../../clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../..; ../../../../..; ../../../../../../../../sam/drivers/gpio; ../../../../../../delay; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../serial/sam_uart; ../../../../../../../../sam/drivers/flashcalw; ../../../../../../../boards; ../../../../../../../../sam/boards/sam4l_ek; ../../../../../../ioport; ../../../../../class/hid; ../../../../../../../../sam/drivers/bpm; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tests_targets_flash.bin
  ILINK.IlinkOutputFile: tests_targets_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x200
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/eic
    ../../../../../../../../sam/drivers/eic/: eic.c
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/usbc
    ../../../../../../../../sam/drivers/usbc/: usbc_host.c
  group sam/drivers/bpm
    ../../../../../../../../sam/drivers/bpm/: bpm.c
  group sam/drivers/flashcalw
    ../../../../../../../../sam/drivers/flashcalw/: flashcalw.c
  group sam/drivers/gpio
    ../../../../../../../../sam/drivers/gpio/: gpio.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/boards/sam4l_ek
    ../../../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c
  group common/services/usb/uhc
    ../../../../: uhc.c
  group common/services/usb/uhc/unit_tests/target
    ../../: unit_tests.c
  group common/services/usb/class/hid/host/mouse
    ../../../../../class/hid/host/mouse/: uhi_hid_mouse.c
  group common/services/clock/sam4l
    ../../../../../../clock/sam4l/: osc.c dfll.c pll.c sysclk.c
  group common/services/serial
    ../../../../../../serial/: usart_serial.c
  group common/services/delay/sam
    ../../../../../../delay/sam/: cycle_counter.c
  group common/services/sleepmgr/sam4l
    ../../../../../../sleepmgr/sam4l/: sleepmgr.c
