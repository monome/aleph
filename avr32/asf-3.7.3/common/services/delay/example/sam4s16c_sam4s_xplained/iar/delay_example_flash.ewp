# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../..; ..; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ../../../../../../sam/boards/sam4s_xplained; ../../../../../utils; ../../../../../../sam/utils/cmsis/sam4s/include; ../../../../gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_xplained
    ../../../../../../sam/boards/sam4s_xplained/: init.c led.c
  group common/services/delay/example
    ../../: delay_example.c
  group common/services/delay/sam
    ../../../sam/: cycle_counter.c
  group common/services/clock/sam4s
    ../../../../clock/sam4s/: sysclk.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
