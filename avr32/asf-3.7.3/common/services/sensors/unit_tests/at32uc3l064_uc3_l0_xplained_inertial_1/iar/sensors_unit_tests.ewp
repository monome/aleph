# IAR project sensors_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=UC3_L0_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../avr32/drivers/scif; ../../..; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/twim; ../../../../../../avr32/drivers/pm; ../../../../../../avr32/drivers/eic; ../../../../serial; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../sleepmgr; ../../../../../utils; ../../../../../../avr32/boards/uc3_l0_xplained; ../../../../clock; ../../../../../utils/stdio/stdio_serial; ..; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../avr32/drivers/flashcdw; ../../../../twi; ../../../../delay; ../../../../serial/uc3_usart; ../../../../../boards; ../../../../../../avr32/drivers/usart; ../../../../../../avr32/utils/preprocessor; ../../../../../../avr32/drivers/intc; ../../../module_config; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/sensors
    ../../../: sensor_bus.c sensor.c sensor_platform.c sensor_nvram.c
  group common/services/sensors/physics
    ../../../physics/: physics.c
  group common/services/sensors/drivers/invensense
    ../../../drivers/invensense/: imu3000.c itg3200.c
  group common/services/sensors/drivers/bosch
    ../../../drivers/bosch/: bma222.c bma250.c bma020.c bma180.c bma150.c bmp.c bma_axis.inc.c bma220.c
  group common/services/sensors/drivers/kionix
    ../../../drivers/kionix/: kxtf9.c
  group common/services/sensors/drivers/osram
    ../../../drivers/osram/: sfh5712.c sfh7770.c
  group common/services/sensors/drivers/honeywell
    ../../../drivers/honeywell/: hmc5883l.c
  group common/services/sensors/drivers/akm
    ../../../drivers/akm/: ak8975.c
  group common/services/sensors/unit_tests
    ../../: unit_tests.c
  group common/services/sleepmgr/uc3
    ../../../../sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3l
    ../../../../clock/uc3l/: osc.c sysclk.c dfll.c
  group common/services/serial
    ../../../../serial/: usart_serial.c
  group common/boards/sensors_xplained
    ../../../../../boards/sensors_xplained/: sensors_xplained.c
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group avr32/drivers/flashcdw
    ../../../../../../avr32/drivers/flashcdw/: flashcdw.c
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm_uc3l.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c exception.s82
  group avr32/drivers/scif
    ../../../../../../avr32/drivers/scif/: scif_uc3l.c
  group avr32/drivers/twim
    ../../../../../../avr32/drivers/twim/: twim.c
  group avr32/drivers/usart
    ../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/eic
    ../../../../../../avr32/drivers/eic/: eic.c
  group avr32/boards/uc3_l0_xplained
    ../../../../../../avr32/boards/uc3_l0_xplained/: init.c led.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
