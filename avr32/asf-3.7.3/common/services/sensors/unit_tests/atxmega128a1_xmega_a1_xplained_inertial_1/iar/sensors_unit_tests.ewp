# IAR project sensors_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-f.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1; BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../xmega/drivers/pmic; ../../..; ../../../../../../xmega/utils; ../../../../twi; ../../../../serial; ../../../../../../xmega/utils/preprocessor; ../../../../serial/xmega_usart; ../../../../../../xmega/drivers/usart; ../../../../../../xmega/drivers/nvm; ../../../../sleepmgr; ../../../../../utils; ../../../../clock; ../../../../../utils/stdio/stdio_serial; ../../../../../../xmega/boards/xmega_a1_xplained; ../../../../../../xmega/boards; ../../../../gpio; ..; ../../../../delay; ../../../../../../xmega/drivers/twi; ../../../../../boards; ../../../../ioport; ../../../../../../xmega/drivers/sleep; ../../../module_config; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1; BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/sensors
    ../../../: sensor_bus.c sensor.c sensor_nvram.c sensor_platform.c
  group common/services/sensors/physics
    ../../../physics/: physics.c
  group common/services/sensors/unit_tests
    ../../: unit_tests.c
  group common/services/sensors/drivers/bosch
    ../../../drivers/bosch/: bma222.c bma250.c bma020.c bma180.c bma150.c bmp.c bma_axis.inc.c bma220.c
  group common/services/sensors/drivers/kionix
    ../../../drivers/kionix/: kxtf9.c
  group common/services/sensors/drivers/osram
    ../../../drivers/osram/: sfh5712.c sfh7770.c
  group common/services/sensors/drivers/honeywell
    ../../../drivers/honeywell/: hmc5883l.c
  group common/services/sensors/drivers/invensense
    ../../../drivers/invensense/: itg3200.c imu3000.c
  group common/services/sensors/drivers/akm
    ../../../drivers/akm/: ak8975.c
  group common/services/sleepmgr/xmega
    ../../../../sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c
  group common/services/serial
    ../../../../serial/: usart_serial.c
  group common/boards/sensors_xplained
    ../../../../../boards/sensors_xplained/: sensors_xplained.c
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group xmega/drivers/twi
    ../../../../../../xmega/drivers/twi/: twis.c twim.c
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a1_xplained
    ../../../../../../xmega/boards/xmega_a1_xplained/: init.c
