# IAR project gfx_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: CONF_GFX_HX8347A_ET024006DHU=1; BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../delay; ../../../../../components/display/hx8347a; ../../..; ../../../../../../xmega/drivers/pmic; ../../../../clock; ../../../../../../xmega/drivers/cpu; ../../../../spi; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/utils; ../../../../ioport; ../../../../../../xmega/drivers/usart; ../../../../../../xmega/boards; ../../../../../utils; ../../../../../../xmega/boards/xplain; ../../../../gpio; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONF_GFX_HX8347A_ET024006DHU=1; BOARD=XPLAIN; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/gfx
    ../../../: gfx_text.c gfx_generic.c sysfont.c gfx_hx8347a_et024006dhu.c
  group common/services/gfx/example1
    ../../: example1.c
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
  group common/services/spi/xmega_usart_spi
    ../../../../spi/xmega_usart_spi/: usart_spi.c
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c
  group common/components/display/hx8347a
    ../../../../../components/display/hx8347a/: hx8347a.c
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xplain
    ../../../../../../xmega/boards/xplain/: init.c
