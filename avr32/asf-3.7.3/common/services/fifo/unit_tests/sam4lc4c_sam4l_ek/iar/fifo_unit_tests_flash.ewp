# IAR project fifo_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..; ../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../serial; ../..; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/boards; ../../../../../../sam/drivers/usart; ../../../../../utils/stdio/stdio_serial; ../../../../../../sam/drivers/flashcalw; ../../../../../../sam/utils/preprocessor; ../../../../../boards; ../../../../../../sam/boards/sam4l_ek; ../../../../ioport; ../../../../delay; ../../..; ../../../../../../sam/drivers/bpm; ../../../../../utils; ../../../../../../sam/utils/header_files; ../../../../../../sam/utils/cmsis/sam4l/include; ../../../../serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fifo_unit_tests_flash.bin
  ILINK.IlinkOutputFile: fifo_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/boards/sam4l_ek
    ../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c
  group sam/drivers/bpm
    ../../../../../../sam/drivers/bpm/: bpm.c
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/flashcalw
    ../../../../../../sam/drivers/flashcalw/: flashcalw.c
  group common/services/clock/sam4l
    ../../../../clock/sam4l/: sysclk.c dfll.c pll.c osc.c
  group common/services/fifo
    ../../../: fifo.c
  group common/services/fifo/unit_tests
    ../../: unit_tests.c
  group common/services/serial
    ../../../../serial/: usart_serial.c
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c
