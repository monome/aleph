# IAR project wtk_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: GFX_INITIALIZED=1; CONF_GFX_HX8347A_ET024006DHU_EBI=1; BOARD=UC3C_EK
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../../avr32/boards; ../..; ../../../../../../avr32/components/display/et024006dhu; ../../../../gfx; ../../../../../../avr32/boards/uc3c_ek; ../../../../../../avr32/components/touch/resistive_touch; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../../utils; ../../../../clock; ../../..; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../utils/membag; ../../../../../../avr32/drivers/adcifa; ../../../../delay; ../../../../../../avr32/drivers/ebi/smc; ../../../../../boards; ../../../../../../avr32/drivers/flashc; ../../../../ioport; ../../../../../../avr32/utils/preprocessor; ../../../../../../avr32/drivers/intc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/wtk
    ../../../: win.c wtk_button.c wtk.c wtk_basic_frame.c wtk_plot.c wtk_icon.c wtk_radio_button.c wtk_slider.c wtk_check_box.c wtk_label.c wtk_frame.c wtk_progress_bar.c
  group common/services/wtk/example1_widgets
    ../../: example1.c widget_gui.c
  group common/services/wtk/example1_widgets/at32uc3c0512c_uc3c_ek
    ../: touch_interface.c
  group common/services/clock/uc3c
    ../../../../clock/uc3c/: osc.c sysclk.c pll.c
  group common/services/gfx
    ../../../../gfx/: gfx_hx8347a_et024006dhu_ebi.c sysfont.c gfx_generic.c gfx_text.c
  group common/utils/membag
    ../../../../../utils/membag/: membag.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/intc
    ../../../../../../avr32/drivers/intc/: intc.c exception.s82
  group avr32/drivers/ebi/smc
    ../../../../../../avr32/drivers/ebi/smc/: smc.c
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/adcifa
    ../../../../../../avr32/drivers/adcifa/: adcifa.c
  group avr32/components/touch/resistive_touch
    ../../../../../../avr32/components/touch/resistive_touch/: rtouch.c
  group avr32/components/display/et024006dhu
    ../../../../../../avr32/components/display/et024006dhu/: et024006dhu.c
  group avr32/boards/uc3c_ek
    ../../../../../../avr32/boards/uc3c_ek/: init.c led.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
