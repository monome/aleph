# IAR project wtk_example1.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=UC3_A3_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../../avr32/boards; ../../../../../../avr32/drivers/pdca; ../../../../../../avr32/drivers/twim; ../../../../gfx; ../../../../../utils/membag; ..; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../../utils; ../../../../../../avr32/drivers/spi; ../../../../../components/touch/mxt; ../../../../clock; ../../..; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../twi; ../../../../../../avr32/boards/uc3_a3_xplained; ../../../../delay; ../../../../../components/display/ili9341; ../../../../spi; ../../../../../boards; ../../../../../../avr32/drivers/flashc; ../../../../ioport; ../../../../spi/uc3_spi; ../../../../../../avr32/utils/preprocessor; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=UC3_A3_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/wtk
    ../../../: win.c wtk.c wtk_basic_frame.c wtk_button.c wtk_plot.c wtk_icon.c wtk_radio_button.c wtk_slider.c wtk_check_box.c wtk_label.c wtk_frame.c wtk_progress_bar.c
  group common/services/wtk/example1_widgets
    ../../: example1.c widget_gui.c
  group common/services/wtk/example1_widgets/at32uc3a3256_uc3_a3_xplained
    ../: touch_interface.c
  group common/services/clock/uc3a3_a4
    ../../../../clock/uc3a3_a4/: sysclk.c
  group common/services/spi/uc3_spi
    ../../../../spi/uc3_spi/: spi_master.c
  group common/services/gfx
    ../../../../gfx/: gfx_ili9341_sdt028atft.c sysfont.c gfx_generic.c gfx_text.c
  group common/components/touch/mxt
    ../../../../../components/touch/mxt/: mxt_device.c
  group common/components/display/ili9341
    ../../../../../components/display/ili9341/: ili9341.c
  group common/utils/membag
    ../../../../../utils/membag/: membag.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/twim
    ../../../../../../avr32/drivers/twim/: twim.c
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/pdca
    ../../../../../../avr32/drivers/pdca/: pdca.c
  group avr32/drivers/spi
    ../../../../../../avr32/drivers/spi/: spi.c
  group avr32/boards/uc3_a3_xplained
    ../../../../../../avr32/boards/uc3_a3_xplained/: init.c led.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
