# IAR project wtk_training.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XMEGA_A1_XPLAINED; CONF_GFX_ILI9341_SDT028ATFT=1; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../xmega/drivers/pmic; ../../../../../../xmega/utils; ../..; ../../../../gfx; ../../../../../utils/membag; ../../../../ioport; ../../../../../../xmega/drivers/usart; ../../../../../utils; ../../../../../components/touch/mxt; ../../../../clock; ..; ../../../../../../xmega/boards/xmega_a1_xplained; ../../../../../../xmega/boards; ../../../../gpio; ../../../../twi; ../../..; ../../../../delay; ../../../../../components/display/ili9341; ../../../../../../xmega/drivers/twi; ../../../../spi; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1_XPLAINED; CONF_GFX_ILI9341_SDT028ATFT=1; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/wtk
    ../../../: win.c wtk.c wtk_basic_frame.c wtk_plot.c wtk_icon.c wtk_radio_button.c wtk_slider.c wtk_check_box.c wtk_button.c wtk_label.c wtk_frame.c wtk_progress_bar.c
  group common/services/wtk/training
    ../../: app_widget.c main.c
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c
  group common/services/gfx
    ../../../../gfx/: gfx_ili9341_sdt028atft.c sysfont.c gfx_generic.c gfx_text.c
  group common/services/spi/xmega_usart_spi
    ../../../../spi/xmega_usart_spi/: usart_spi.c
  group common/components/touch/mxt
    ../../../../../components/touch/mxt/: mxt_device.c
  group common/components/display/ili9341
    ../../../../../components/display/ili9341/: ili9341.c
  group common/utils/membag
    ../../../../../utils/membag/: membag.c
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group xmega/drivers/twi
    ../../../../../../xmega/drivers/twi/: twis.c twim.c
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a1_xplained
    ../../../../../../xmega/boards/xmega_a1_xplained/: init.c
