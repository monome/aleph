# IAR project sleepmgr_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../delay; ..; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/boards; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/header_files; ../../../../../../sam/drivers/flashcalw; ../../../../../../sam/utils/preprocessor; ../../../../../boards; ../../../../../../sam/boards/sam4l_ek; ../../../../../../sam/drivers/bpm; ../../../../ioport; ../../..; ../../../../../utils; ../../../../../../sam/utils/cmsis/sam4l/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepmgr_example_flash.bin
  ILINK.IlinkOutputFile: sleepmgr_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/drivers/bpm
    ../../../../../../sam/drivers/bpm/: bpm.c
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/flashcalw
    ../../../../../../sam/drivers/flashcalw/: flashcalw.c
  group sam/boards/sam4l_ek
    ../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c
  group common/services/sleepmgr/sam4l
    ../../../sam4l/: sleepmgr.c
  group common/services/sleepmgr/example
    ../../: sleepmgr_example_sam4l_ast.c
  group common/services/sleepmgr/example/sam4lc4c_sam4l_ek
    ../: ast.c
  group common/services/clock/sam4l
    ../../../../clock/sam4l/: sysclk.c dfll.c pll.c osc.c
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
